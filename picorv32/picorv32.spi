* Coriolis Structural SPICE Driver
* Generated on Apr 13, 2023, 13:38
* Cell/Subckt "picorv32".
*
* INTERF vss
* INTERF vdd
* INTERF trap
* INTERF trace_valid
* INTERF trace_data[9]
* INTERF trace_data[8]
* INTERF trace_data[7]
* INTERF trace_data[6]
* INTERF trace_data[5]
* INTERF trace_data[4]
* INTERF trace_data[35]
* INTERF trace_data[34]
* INTERF trace_data[33]
* INTERF trace_data[32]
* INTERF trace_data[31]
* INTERF trace_data[30]
* INTERF trace_data[3]
* INTERF trace_data[29]
* INTERF trace_data[28]
* INTERF trace_data[27]
* INTERF trace_data[26]
* INTERF trace_data[25]
* INTERF trace_data[24]
* INTERF trace_data[23]
* INTERF trace_data[22]
* INTERF trace_data[21]
* INTERF trace_data[20]
* INTERF trace_data[2]
* INTERF trace_data[19]
* INTERF trace_data[18]
* INTERF trace_data[17]
* INTERF trace_data[16]
* INTERF trace_data[15]
* INTERF trace_data[14]
* INTERF trace_data[13]
* INTERF trace_data[12]
* INTERF trace_data[11]
* INTERF trace_data[10]
* INTERF trace_data[1]
* INTERF trace_data[0]
* INTERF resetn
* INTERF pcpi_wr
* INTERF pcpi_wait
* INTERF pcpi_valid
* INTERF pcpi_rs2[9]
* INTERF pcpi_rs2[8]
* INTERF pcpi_rs2[31]
* INTERF pcpi_rs2[30]
* INTERF pcpi_rs2[29]
* INTERF pcpi_rs2[28]
* INTERF pcpi_rs2[27]
* INTERF pcpi_rs2[26]
* INTERF pcpi_rs2[25]
* INTERF pcpi_rs2[24]
* INTERF pcpi_rs2[23]
* INTERF pcpi_rs2[22]
* INTERF pcpi_rs2[21]
* INTERF pcpi_rs2[20]
* INTERF pcpi_rs2[19]
* INTERF pcpi_rs2[18]
* INTERF pcpi_rs2[17]
* INTERF pcpi_rs2[16]
* INTERF pcpi_rs2[15]
* INTERF pcpi_rs2[14]
* INTERF pcpi_rs2[13]
* INTERF pcpi_rs2[12]
* INTERF pcpi_rs2[11]
* INTERF pcpi_rs2[10]
* INTERF pcpi_rs1[9]
* INTERF pcpi_rs1[8]
* INTERF pcpi_rs1[7]
* INTERF pcpi_rs1[6]
* INTERF pcpi_rs1[5]
* INTERF pcpi_rs1[4]
* INTERF pcpi_rs1[31]
* INTERF pcpi_rs1[30]
* INTERF pcpi_rs1[3]
* INTERF pcpi_rs1[29]
* INTERF pcpi_rs1[28]
* INTERF pcpi_rs1[27]
* INTERF pcpi_rs1[26]
* INTERF pcpi_rs1[25]
* INTERF pcpi_rs1[24]
* INTERF pcpi_rs1[23]
* INTERF pcpi_rs1[22]
* INTERF pcpi_rs1[21]
* INTERF pcpi_rs1[20]
* INTERF pcpi_rs1[2]
* INTERF pcpi_rs1[19]
* INTERF pcpi_rs1[18]
* INTERF pcpi_rs1[17]
* INTERF pcpi_rs1[16]
* INTERF pcpi_rs1[15]
* INTERF pcpi_rs1[14]
* INTERF pcpi_rs1[13]
* INTERF pcpi_rs1[12]
* INTERF pcpi_rs1[11]
* INTERF pcpi_rs1[10]
* INTERF pcpi_rs1[1]
* INTERF pcpi_rs1[0]
* INTERF pcpi_ready
* INTERF pcpi_rd[9]
* INTERF pcpi_rd[8]
* INTERF pcpi_rd[7]
* INTERF pcpi_rd[6]
* INTERF pcpi_rd[5]
* INTERF pcpi_rd[4]
* INTERF pcpi_rd[31]
* INTERF pcpi_rd[30]
* INTERF pcpi_rd[3]
* INTERF pcpi_rd[29]
* INTERF pcpi_rd[28]
* INTERF pcpi_rd[27]
* INTERF pcpi_rd[26]
* INTERF pcpi_rd[25]
* INTERF pcpi_rd[24]
* INTERF pcpi_rd[23]
* INTERF pcpi_rd[22]
* INTERF pcpi_rd[21]
* INTERF pcpi_rd[20]
* INTERF pcpi_rd[2]
* INTERF pcpi_rd[19]
* INTERF pcpi_rd[18]
* INTERF pcpi_rd[17]
* INTERF pcpi_rd[16]
* INTERF pcpi_rd[15]
* INTERF pcpi_rd[14]
* INTERF pcpi_rd[13]
* INTERF pcpi_rd[12]
* INTERF pcpi_rd[11]
* INTERF pcpi_rd[10]
* INTERF pcpi_rd[1]
* INTERF pcpi_rd[0]
* INTERF pcpi_insn[9]
* INTERF pcpi_insn[8]
* INTERF pcpi_insn[7]
* INTERF pcpi_insn[6]
* INTERF pcpi_insn[5]
* INTERF pcpi_insn[4]
* INTERF pcpi_insn[31]
* INTERF pcpi_insn[30]
* INTERF pcpi_insn[3]
* INTERF pcpi_insn[29]
* INTERF pcpi_insn[28]
* INTERF pcpi_insn[27]
* INTERF pcpi_insn[26]
* INTERF pcpi_insn[25]
* INTERF pcpi_insn[24]
* INTERF pcpi_insn[23]
* INTERF pcpi_insn[22]
* INTERF pcpi_insn[21]
* INTERF pcpi_insn[20]
* INTERF pcpi_insn[2]
* INTERF pcpi_insn[19]
* INTERF pcpi_insn[18]
* INTERF pcpi_insn[17]
* INTERF pcpi_insn[16]
* INTERF pcpi_insn[15]
* INTERF pcpi_insn[14]
* INTERF pcpi_insn[13]
* INTERF pcpi_insn[12]
* INTERF pcpi_insn[11]
* INTERF pcpi_insn[10]
* INTERF pcpi_insn[1]
* INTERF pcpi_insn[0]
* INTERF mem_wstrb[3]
* INTERF mem_wstrb[2]
* INTERF mem_wstrb[1]
* INTERF mem_wstrb[0]
* INTERF mem_wdata[9]
* INTERF mem_wdata[8]
* INTERF mem_wdata[7]
* INTERF mem_wdata[6]
* INTERF mem_wdata[5]
* INTERF mem_wdata[4]
* INTERF mem_wdata[31]
* INTERF mem_wdata[30]
* INTERF mem_wdata[3]
* INTERF mem_wdata[29]
* INTERF mem_wdata[28]
* INTERF mem_wdata[27]
* INTERF mem_wdata[26]
* INTERF mem_wdata[25]
* INTERF mem_wdata[24]
* INTERF mem_wdata[23]
* INTERF mem_wdata[22]
* INTERF mem_wdata[21]
* INTERF mem_wdata[20]
* INTERF mem_wdata[2]
* INTERF mem_wdata[19]
* INTERF mem_wdata[18]
* INTERF mem_wdata[17]
* INTERF mem_wdata[16]
* INTERF mem_wdata[15]
* INTERF mem_wdata[14]
* INTERF mem_wdata[13]
* INTERF mem_wdata[12]
* INTERF mem_wdata[11]
* INTERF mem_wdata[10]
* INTERF mem_wdata[1]
* INTERF mem_wdata[0]
* INTERF mem_valid
* INTERF mem_ready
* INTERF mem_rdata[9]
* INTERF mem_rdata[8]
* INTERF mem_rdata[7]
* INTERF mem_rdata[6]
* INTERF mem_rdata[5]
* INTERF mem_rdata[4]
* INTERF mem_rdata[31]
* INTERF mem_rdata[30]
* INTERF mem_rdata[3]
* INTERF mem_rdata[29]
* INTERF mem_rdata[28]
* INTERF mem_rdata[27]
* INTERF mem_rdata[26]
* INTERF mem_rdata[25]
* INTERF mem_rdata[24]
* INTERF mem_rdata[23]
* INTERF mem_rdata[22]
* INTERF mem_rdata[21]
* INTERF mem_rdata[20]
* INTERF mem_rdata[2]
* INTERF mem_rdata[19]
* INTERF mem_rdata[18]
* INTERF mem_rdata[17]
* INTERF mem_rdata[16]
* INTERF mem_rdata[15]
* INTERF mem_rdata[14]
* INTERF mem_rdata[13]
* INTERF mem_rdata[12]
* INTERF mem_rdata[11]
* INTERF mem_rdata[10]
* INTERF mem_rdata[1]
* INTERF mem_rdata[0]
* INTERF mem_la_wstrb[3]
* INTERF mem_la_wstrb[2]
* INTERF mem_la_wstrb[1]
* INTERF mem_la_wstrb[0]
* INTERF mem_la_write
* INTERF mem_la_wdata[9]
* INTERF mem_la_wdata[8]
* INTERF mem_la_wdata[7]
* INTERF mem_la_wdata[6]
* INTERF mem_la_wdata[5]
* INTERF mem_la_wdata[4]
* INTERF mem_la_wdata[31]
* INTERF mem_la_wdata[30]
* INTERF mem_la_wdata[3]
* INTERF mem_la_wdata[29]
* INTERF mem_la_wdata[28]
* INTERF mem_la_wdata[27]
* INTERF mem_la_wdata[26]
* INTERF mem_la_wdata[25]
* INTERF mem_la_wdata[24]
* INTERF mem_la_wdata[23]
* INTERF mem_la_wdata[22]
* INTERF mem_la_wdata[21]
* INTERF mem_la_wdata[20]
* INTERF mem_la_wdata[2]
* INTERF mem_la_wdata[19]
* INTERF mem_la_wdata[18]
* INTERF mem_la_wdata[17]
* INTERF mem_la_wdata[16]
* INTERF mem_la_wdata[15]
* INTERF mem_la_wdata[14]
* INTERF mem_la_wdata[13]
* INTERF mem_la_wdata[12]
* INTERF mem_la_wdata[11]
* INTERF mem_la_wdata[10]
* INTERF mem_la_wdata[1]
* INTERF mem_la_wdata[0]
* INTERF mem_la_read
* INTERF mem_la_addr[9]
* INTERF mem_la_addr[8]
* INTERF mem_la_addr[7]
* INTERF mem_la_addr[6]
* INTERF mem_la_addr[5]
* INTERF mem_la_addr[4]
* INTERF mem_la_addr[31]
* INTERF mem_la_addr[30]
* INTERF mem_la_addr[3]
* INTERF mem_la_addr[29]
* INTERF mem_la_addr[28]
* INTERF mem_la_addr[27]
* INTERF mem_la_addr[26]
* INTERF mem_la_addr[25]
* INTERF mem_la_addr[24]
* INTERF mem_la_addr[23]
* INTERF mem_la_addr[22]
* INTERF mem_la_addr[21]
* INTERF mem_la_addr[20]
* INTERF mem_la_addr[2]
* INTERF mem_la_addr[19]
* INTERF mem_la_addr[18]
* INTERF mem_la_addr[17]
* INTERF mem_la_addr[16]
* INTERF mem_la_addr[15]
* INTERF mem_la_addr[14]
* INTERF mem_la_addr[13]
* INTERF mem_la_addr[12]
* INTERF mem_la_addr[11]
* INTERF mem_la_addr[10]
* INTERF mem_la_addr[1]
* INTERF mem_la_addr[0]
* INTERF mem_instr
* INTERF mem_addr[9]
* INTERF mem_addr[8]
* INTERF mem_addr[7]
* INTERF mem_addr[6]
* INTERF mem_addr[5]
* INTERF mem_addr[4]
* INTERF mem_addr[31]
* INTERF mem_addr[30]
* INTERF mem_addr[3]
* INTERF mem_addr[29]
* INTERF mem_addr[28]
* INTERF mem_addr[27]
* INTERF mem_addr[26]
* INTERF mem_addr[25]
* INTERF mem_addr[24]
* INTERF mem_addr[23]
* INTERF mem_addr[22]
* INTERF mem_addr[21]
* INTERF mem_addr[20]
* INTERF mem_addr[2]
* INTERF mem_addr[19]
* INTERF mem_addr[18]
* INTERF mem_addr[17]
* INTERF mem_addr[16]
* INTERF mem_addr[15]
* INTERF mem_addr[14]
* INTERF mem_addr[13]
* INTERF mem_addr[12]
* INTERF mem_addr[11]
* INTERF mem_addr[10]
* INTERF mem_addr[1]
* INTERF mem_addr[0]
* INTERF irq[9]
* INTERF irq[8]
* INTERF irq[7]
* INTERF irq[6]
* INTERF irq[5]
* INTERF irq[4]
* INTERF irq[31]
* INTERF irq[30]
* INTERF irq[3]
* INTERF irq[29]
* INTERF irq[28]
* INTERF irq[27]
* INTERF irq[26]
* INTERF irq[25]
* INTERF irq[24]
* INTERF irq[23]
* INTERF irq[22]
* INTERF irq[21]
* INTERF irq[20]
* INTERF irq[2]
* INTERF irq[19]
* INTERF irq[18]
* INTERF irq[17]
* INTERF irq[16]
* INTERF irq[15]
* INTERF irq[14]
* INTERF irq[13]
* INTERF irq[12]
* INTERF irq[11]
* INTERF irq[10]
* INTERF irq[1]
* INTERF irq[0]
* INTERF eoi[9]
* INTERF eoi[8]
* INTERF eoi[7]
* INTERF eoi[6]
* INTERF eoi[5]
* INTERF eoi[4]
* INTERF eoi[31]
* INTERF eoi[30]
* INTERF eoi[3]
* INTERF eoi[29]
* INTERF eoi[28]
* INTERF eoi[27]
* INTERF eoi[26]
* INTERF eoi[25]
* INTERF eoi[24]
* INTERF eoi[23]
* INTERF eoi[22]
* INTERF eoi[21]
* INTERF eoi[20]
* INTERF eoi[2]
* INTERF eoi[19]
* INTERF eoi[18]
* INTERF eoi[17]
* INTERF eoi[16]
* INTERF eoi[15]
* INTERF eoi[14]
* INTERF eoi[13]
* INTERF eoi[12]
* INTERF eoi[11]
* INTERF eoi[10]
* INTERF eoi[1]
* INTERF eoi[0]
* INTERF clk

* Terminal models (aka standard cells) used througout all the hierarchy.
.include sff1_x4.spi
.include nand3_x0.spi
.include a3_x2.spi
.include mx2_x2.spi
.include nand4_x0.spi
.include a2_x2.spi
.include nand2_x0.spi
.include oa22_x2.spi
.include o2_x2.spi
.include inv_x0.spi
.include ao22_x2.spi
.include nor3_x0.spi
.include nor2_x0.spi
.include mx3_x2.spi
.include xr2_x1.spi
.include nor4_x0.spi
.include nxr2_x1.spi
.include a4_x2.spi
.include o3_x2.spi
.include o4_x2.spi
.include zero_x1.spi
.include buf_x1.spi

* Non-terminal models (part of the user's design hierarchy).

.subckt picorv32 0 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 172 173 174 175 176 177 178 179 180 181 182 183 184 185 186 187 188 189 190 191 192 193 194 195 196 197 198 199 200 201 202 203 204 205 206 207 208 209 210 211 212 213 214 215 216 217 218 219 220 221 222 223 224 225 226 227 228 229 230 231 232 233 234 235 236 237 238 239 240 241 242 243 244 245 246 247 248 249 250 251 252 253 254 255 256 257 258 259 260 261 262 263 264 265 266 267 268 269 270 271 272 273 274 275 276 277 278 279 280 281 282 283 284 285 286 287 288 289 290 291 292 293 294 295 303 304 305 306 310 311 312 313 314 315 316 317 318 319 320 321 322 323 324 325 326 327 328 329 330 331 332 333 334 335 336 337 338 339 340 341 342 345 378 379 380 381 382 383 384 385 386 387 388 389 390 391 392 393 394 395 396 397 398 399 400 401 402 403 404 405 406 407 408 409 410 411 412 413 414 415 416 417 418 419 420 421 422 423 424 425 426 427 428 429 430 431 432 433 434 435 436 437 438 439 440 441 442 443 444 445 446 447 448 449 450 451 452 453 454 455 456 457 458 459 460 461 462 463 464 465 466 467 468 469 470 471 472 473 474 475 476 477 478 479 480 485 486 487 488 489 490 491 492 493 494 495 496 497 498 499 500 501 502 503 504 505 506 507 508 509 510 511 512 513 514 515 516 539 540 541 542 543 544 545 546 547 548 549 550 551 552 553 554 555 556 557 558 559 560 561 562 563 564 565 566 567 568 569 570 612 613 614 615 616 617 618 619 620 621 622 623 624 625 626 627 628 629 630 631 632 633 634 635 636 637 638 639 640 641 642 643 1872
* NET     0 = vss
* NET     1 = vdd
* NET     2 = trap
* NET     3 = trace_valid
* NET     4 = trace_data[9]
* NET     5 = trace_data[8]
* NET     6 = trace_data[7]
* NET     7 = trace_data[6]
* NET     8 = trace_data[5]
* NET     9 = trace_data[4]
* NET    10 = trace_data[35]
* NET    11 = trace_data[34]
* NET    12 = trace_data[33]
* NET    13 = trace_data[32]
* NET    14 = trace_data[31]
* NET    15 = trace_data[30]
* NET    16 = trace_data[3]
* NET    17 = trace_data[29]
* NET    18 = trace_data[28]
* NET    19 = trace_data[27]
* NET    20 = trace_data[26]
* NET    21 = trace_data[25]
* NET    22 = trace_data[24]
* NET    23 = trace_data[23]
* NET    24 = trace_data[22]
* NET    25 = trace_data[21]
* NET    26 = trace_data[20]
* NET    27 = trace_data[2]
* NET    28 = trace_data[19]
* NET    29 = trace_data[18]
* NET    30 = trace_data[17]
* NET    31 = trace_data[16]
* NET    32 = trace_data[15]
* NET    33 = trace_data[14]
* NET    34 = trace_data[13]
* NET    35 = trace_data[12]
* NET    36 = trace_data[11]
* NET    37 = trace_data[10]
* NET    38 = trace_data[1]
* NET    39 = trace_data[0]
* NET    40 = resetn
* NET    41 = reg_sh[4]
* NET    42 = reg_sh[3]
* NET    43 = reg_sh[2]
* NET    44 = reg_sh[1]
* NET    45 = reg_sh[0]
* NET    46 = reg_pc[9]
* NET    47 = reg_pc[8]
* NET    48 = reg_pc[7]
* NET    49 = reg_pc[6]
* NET    50 = reg_pc[5]
* NET    51 = reg_pc[4]
* NET    52 = reg_pc[31]
* NET    53 = reg_pc[30]
* NET    54 = reg_pc[3]
* NET    55 = reg_pc[29]
* NET    56 = reg_pc[28]
* NET    57 = reg_pc[27]
* NET    58 = reg_pc[26]
* NET    59 = reg_pc[25]
* NET    60 = reg_pc[24]
* NET    61 = reg_pc[23]
* NET    62 = reg_pc[22]
* NET    63 = reg_pc[21]
* NET    64 = reg_pc[20]
* NET    65 = reg_pc[2]
* NET    66 = reg_pc[19]
* NET    67 = reg_pc[18]
* NET    68 = reg_pc[17]
* NET    69 = reg_pc[16]
* NET    70 = reg_pc[15]
* NET    71 = reg_pc[14]
* NET    72 = reg_pc[13]
* NET    73 = reg_pc[12]
* NET    74 = reg_pc[11]
* NET    75 = reg_pc[10]
* NET    76 = reg_pc[1]
* NET    77 = reg_out[9]
* NET    78 = reg_out[8]
* NET    79 = reg_out[7]
* NET    80 = reg_out[6]
* NET    81 = reg_out[5]
* NET    82 = reg_out[4]
* NET    83 = reg_out[31]
* NET    84 = reg_out[30]
* NET    85 = reg_out[3]
* NET    86 = reg_out[29]
* NET    87 = reg_out[28]
* NET    88 = reg_out[27]
* NET    89 = reg_out[26]
* NET    90 = reg_out[25]
* NET    91 = reg_out[24]
* NET    92 = reg_out[23]
* NET    93 = reg_out[22]
* NET    94 = reg_out[21]
* NET    95 = reg_out[20]
* NET    96 = reg_out[2]
* NET    97 = reg_out[19]
* NET    98 = reg_out[18]
* NET    99 = reg_out[17]
* NET   100 = reg_out[16]
* NET   101 = reg_out[15]
* NET   102 = reg_out[14]
* NET   103 = reg_out[13]
* NET   104 = reg_out[12]
* NET   105 = reg_out[11]
* NET   106 = reg_out[10]
* NET   107 = reg_out[1]
* NET   108 = reg_out[0]
* NET   109 = reg_next_pc[9]
* NET   110 = reg_next_pc[8]
* NET   111 = reg_next_pc[7]
* NET   112 = reg_next_pc[6]
* NET   113 = reg_next_pc[5]
* NET   114 = reg_next_pc[4]
* NET   115 = reg_next_pc[31]
* NET   116 = reg_next_pc[30]
* NET   117 = reg_next_pc[3]
* NET   118 = reg_next_pc[29]
* NET   119 = reg_next_pc[28]
* NET   120 = reg_next_pc[27]
* NET   121 = reg_next_pc[26]
* NET   122 = reg_next_pc[25]
* NET   123 = reg_next_pc[24]
* NET   124 = reg_next_pc[23]
* NET   125 = reg_next_pc[22]
* NET   126 = reg_next_pc[21]
* NET   127 = reg_next_pc[20]
* NET   128 = reg_next_pc[2]
* NET   129 = reg_next_pc[19]
* NET   130 = reg_next_pc[18]
* NET   131 = reg_next_pc[17]
* NET   132 = reg_next_pc[16]
* NET   133 = reg_next_pc[15]
* NET   134 = reg_next_pc[14]
* NET   135 = reg_next_pc[13]
* NET   136 = reg_next_pc[12]
* NET   137 = reg_next_pc[11]
* NET   138 = reg_next_pc[10]
* NET   139 = reg_next_pc[1]
* NET   140 = procmux_1463_Y[9]
* NET   141 = procmux_1463_Y[8]
* NET   142 = procmux_1463_Y[7]
* NET   143 = procmux_1463_Y[6]
* NET   144 = procmux_1463_Y[5]
* NET   145 = procmux_1463_Y[4]
* NET   146 = procmux_1463_Y[31]
* NET   147 = procmux_1463_Y[30]
* NET   148 = procmux_1463_Y[3]
* NET   149 = procmux_1463_Y[29]
* NET   150 = procmux_1463_Y[28]
* NET   151 = procmux_1463_Y[27]
* NET   152 = procmux_1463_Y[26]
* NET   153 = procmux_1463_Y[25]
* NET   154 = procmux_1463_Y[24]
* NET   155 = procmux_1463_Y[23]
* NET   156 = procmux_1463_Y[22]
* NET   157 = procmux_1463_Y[21]
* NET   158 = procmux_1463_Y[20]
* NET   159 = procmux_1463_Y[2]
* NET   160 = procmux_1463_Y[19]
* NET   161 = procmux_1463_Y[18]
* NET   162 = procmux_1463_Y[17]
* NET   163 = procmux_1463_Y[16]
* NET   164 = procmux_1463_Y[15]
* NET   165 = procmux_1463_Y[14]
* NET   166 = procmux_1463_Y[13]
* NET   167 = procmux_1463_Y[12]
* NET   168 = procmux_1463_Y[11]
* NET   169 = procmux_1463_Y[10]
* NET   170 = procmux_1463_Y[1]
* NET   171 = procmux_1463_Y[0]
* NET   172 = pcpi_wr
* NET   173 = pcpi_wait
* NET   174 = pcpi_valid
* NET   175 = pcpi_rs2[9]
* NET   176 = pcpi_rs2[8]
* NET   177 = pcpi_rs2[31]
* NET   178 = pcpi_rs2[30]
* NET   179 = pcpi_rs2[29]
* NET   180 = pcpi_rs2[28]
* NET   181 = pcpi_rs2[27]
* NET   182 = pcpi_rs2[26]
* NET   183 = pcpi_rs2[25]
* NET   184 = pcpi_rs2[24]
* NET   185 = pcpi_rs2[23]
* NET   186 = pcpi_rs2[22]
* NET   187 = pcpi_rs2[21]
* NET   188 = pcpi_rs2[20]
* NET   189 = pcpi_rs2[19]
* NET   190 = pcpi_rs2[18]
* NET   191 = pcpi_rs2[17]
* NET   192 = pcpi_rs2[16]
* NET   193 = pcpi_rs2[15]
* NET   194 = pcpi_rs2[14]
* NET   195 = pcpi_rs2[13]
* NET   196 = pcpi_rs2[12]
* NET   197 = pcpi_rs2[11]
* NET   198 = pcpi_rs2[10]
* NET   199 = pcpi_rs1[9]
* NET   200 = pcpi_rs1[8]
* NET   201 = pcpi_rs1[7]
* NET   202 = pcpi_rs1[6]
* NET   203 = pcpi_rs1[5]
* NET   204 = pcpi_rs1[4]
* NET   205 = pcpi_rs1[31]
* NET   206 = pcpi_rs1[30]
* NET   207 = pcpi_rs1[3]
* NET   208 = pcpi_rs1[29]
* NET   209 = pcpi_rs1[28]
* NET   210 = pcpi_rs1[27]
* NET   211 = pcpi_rs1[26]
* NET   212 = pcpi_rs1[25]
* NET   213 = pcpi_rs1[24]
* NET   214 = pcpi_rs1[23]
* NET   215 = pcpi_rs1[22]
* NET   216 = pcpi_rs1[21]
* NET   217 = pcpi_rs1[20]
* NET   218 = pcpi_rs1[2]
* NET   219 = pcpi_rs1[19]
* NET   220 = pcpi_rs1[18]
* NET   221 = pcpi_rs1[17]
* NET   222 = pcpi_rs1[16]
* NET   223 = pcpi_rs1[15]
* NET   224 = pcpi_rs1[14]
* NET   225 = pcpi_rs1[13]
* NET   226 = pcpi_rs1[12]
* NET   227 = pcpi_rs1[11]
* NET   228 = pcpi_rs1[10]
* NET   229 = pcpi_rs1[1]
* NET   230 = pcpi_rs1[0]
* NET   231 = pcpi_ready
* NET   232 = pcpi_rd[9]
* NET   233 = pcpi_rd[8]
* NET   234 = pcpi_rd[7]
* NET   235 = pcpi_rd[6]
* NET   236 = pcpi_rd[5]
* NET   237 = pcpi_rd[4]
* NET   238 = pcpi_rd[31]
* NET   239 = pcpi_rd[30]
* NET   240 = pcpi_rd[3]
* NET   241 = pcpi_rd[29]
* NET   242 = pcpi_rd[28]
* NET   243 = pcpi_rd[27]
* NET   244 = pcpi_rd[26]
* NET   245 = pcpi_rd[25]
* NET   246 = pcpi_rd[24]
* NET   247 = pcpi_rd[23]
* NET   248 = pcpi_rd[22]
* NET   249 = pcpi_rd[21]
* NET   250 = pcpi_rd[20]
* NET   251 = pcpi_rd[2]
* NET   252 = pcpi_rd[19]
* NET   253 = pcpi_rd[18]
* NET   254 = pcpi_rd[17]
* NET   255 = pcpi_rd[16]
* NET   256 = pcpi_rd[15]
* NET   257 = pcpi_rd[14]
* NET   258 = pcpi_rd[13]
* NET   259 = pcpi_rd[12]
* NET   260 = pcpi_rd[11]
* NET   261 = pcpi_rd[10]
* NET   262 = pcpi_rd[1]
* NET   263 = pcpi_rd[0]
* NET   264 = pcpi_insn[9]
* NET   265 = pcpi_insn[8]
* NET   266 = pcpi_insn[7]
* NET   267 = pcpi_insn[6]
* NET   268 = pcpi_insn[5]
* NET   269 = pcpi_insn[4]
* NET   270 = pcpi_insn[31]
* NET   271 = pcpi_insn[30]
* NET   272 = pcpi_insn[3]
* NET   273 = pcpi_insn[29]
* NET   274 = pcpi_insn[28]
* NET   275 = pcpi_insn[27]
* NET   276 = pcpi_insn[26]
* NET   277 = pcpi_insn[25]
* NET   278 = pcpi_insn[24]
* NET   279 = pcpi_insn[23]
* NET   280 = pcpi_insn[22]
* NET   281 = pcpi_insn[21]
* NET   282 = pcpi_insn[20]
* NET   283 = pcpi_insn[2]
* NET   284 = pcpi_insn[19]
* NET   285 = pcpi_insn[18]
* NET   286 = pcpi_insn[17]
* NET   287 = pcpi_insn[16]
* NET   288 = pcpi_insn[15]
* NET   289 = pcpi_insn[14]
* NET   290 = pcpi_insn[13]
* NET   291 = pcpi_insn[12]
* NET   292 = pcpi_insn[11]
* NET   293 = pcpi_insn[10]
* NET   294 = pcpi_insn[1]
* NET   295 = pcpi_insn[0]
* NET   296 = n0_reg_sh_4_0_4
* NET   297 = n0_reg_sh_4_0_3
* NET   298 = n0_reg_sh_4_0_2
* NET   299 = n0_is_sltiu_bltu_sltu_0_0
* NET   300 = n0_is_slti_blt_slt_0_0
* NET   301 = n0_is_lui_auipc_jal_0_0
* NET   302 = n0_decoder_trigger_0_0
* NET   303 = mem_wstrb[3]
* NET   304 = mem_wstrb[2]
* NET   305 = mem_wstrb[1]
* NET   306 = mem_wstrb[0]
* NET   307 = mem_wordsize[2]
* NET   308 = mem_wordsize[1]
* NET   309 = mem_wordsize[0]
* NET   310 = mem_wdata[9]
* NET   311 = mem_wdata[8]
* NET   312 = mem_wdata[7]
* NET   313 = mem_wdata[6]
* NET   314 = mem_wdata[5]
* NET   315 = mem_wdata[4]
* NET   316 = mem_wdata[31]
* NET   317 = mem_wdata[30]
* NET   318 = mem_wdata[3]
* NET   319 = mem_wdata[29]
* NET   320 = mem_wdata[28]
* NET   321 = mem_wdata[27]
* NET   322 = mem_wdata[26]
* NET   323 = mem_wdata[25]
* NET   324 = mem_wdata[24]
* NET   325 = mem_wdata[23]
* NET   326 = mem_wdata[22]
* NET   327 = mem_wdata[21]
* NET   328 = mem_wdata[20]
* NET   329 = mem_wdata[2]
* NET   330 = mem_wdata[19]
* NET   331 = mem_wdata[18]
* NET   332 = mem_wdata[17]
* NET   333 = mem_wdata[16]
* NET   334 = mem_wdata[15]
* NET   335 = mem_wdata[14]
* NET   336 = mem_wdata[13]
* NET   337 = mem_wdata[12]
* NET   338 = mem_wdata[11]
* NET   339 = mem_wdata[10]
* NET   340 = mem_wdata[1]
* NET   341 = mem_wdata[0]
* NET   342 = mem_valid
* NET   343 = mem_state[1]
* NET   344 = mem_state[0]
* NET   345 = mem_ready
* NET   346 = mem_rdata_q[9]
* NET   347 = mem_rdata_q[8]
* NET   348 = mem_rdata_q[7]
* NET   349 = mem_rdata_q[6]
* NET   350 = mem_rdata_q[5]
* NET   351 = mem_rdata_q[4]
* NET   352 = mem_rdata_q[31]
* NET   353 = mem_rdata_q[30]
* NET   354 = mem_rdata_q[3]
* NET   355 = mem_rdata_q[29]
* NET   356 = mem_rdata_q[28]
* NET   357 = mem_rdata_q[27]
* NET   358 = mem_rdata_q[26]
* NET   359 = mem_rdata_q[25]
* NET   360 = mem_rdata_q[24]
* NET   361 = mem_rdata_q[23]
* NET   362 = mem_rdata_q[22]
* NET   363 = mem_rdata_q[21]
* NET   364 = mem_rdata_q[20]
* NET   365 = mem_rdata_q[2]
* NET   366 = mem_rdata_q[19]
* NET   367 = mem_rdata_q[18]
* NET   368 = mem_rdata_q[17]
* NET   369 = mem_rdata_q[16]
* NET   370 = mem_rdata_q[15]
* NET   371 = mem_rdata_q[14]
* NET   372 = mem_rdata_q[13]
* NET   373 = mem_rdata_q[12]
* NET   374 = mem_rdata_q[11]
* NET   375 = mem_rdata_q[10]
* NET   376 = mem_rdata_q[1]
* NET   377 = mem_rdata_q[0]
* NET   378 = mem_rdata[9]
* NET   379 = mem_rdata[8]
* NET   380 = mem_rdata[7]
* NET   381 = mem_rdata[6]
* NET   382 = mem_rdata[5]
* NET   383 = mem_rdata[4]
* NET   384 = mem_rdata[31]
* NET   385 = mem_rdata[30]
* NET   386 = mem_rdata[3]
* NET   387 = mem_rdata[29]
* NET   388 = mem_rdata[28]
* NET   389 = mem_rdata[27]
* NET   390 = mem_rdata[26]
* NET   391 = mem_rdata[25]
* NET   392 = mem_rdata[24]
* NET   393 = mem_rdata[23]
* NET   394 = mem_rdata[22]
* NET   395 = mem_rdata[21]
* NET   396 = mem_rdata[20]
* NET   397 = mem_rdata[2]
* NET   398 = mem_rdata[19]
* NET   399 = mem_rdata[18]
* NET   400 = mem_rdata[17]
* NET   401 = mem_rdata[16]
* NET   402 = mem_rdata[15]
* NET   403 = mem_rdata[14]
* NET   404 = mem_rdata[13]
* NET   405 = mem_rdata[12]
* NET   406 = mem_rdata[11]
* NET   407 = mem_rdata[10]
* NET   408 = mem_rdata[1]
* NET   409 = mem_rdata[0]
* NET   410 = mem_la_wstrb[3]
* NET   411 = mem_la_wstrb[2]
* NET   412 = mem_la_wstrb[1]
* NET   413 = mem_la_wstrb[0]
* NET   414 = mem_la_write
* NET   415 = mem_la_wdata[9]
* NET   416 = mem_la_wdata[8]
* NET   417 = mem_la_wdata[7]
* NET   418 = mem_la_wdata[6]
* NET   419 = mem_la_wdata[5]
* NET   420 = mem_la_wdata[4]
* NET   421 = mem_la_wdata[31]
* NET   422 = mem_la_wdata[30]
* NET   423 = mem_la_wdata[3]
* NET   424 = mem_la_wdata[29]
* NET   425 = mem_la_wdata[28]
* NET   426 = mem_la_wdata[27]
* NET   427 = mem_la_wdata[26]
* NET   428 = mem_la_wdata[25]
* NET   429 = mem_la_wdata[24]
* NET   430 = mem_la_wdata[23]
* NET   431 = mem_la_wdata[22]
* NET   432 = mem_la_wdata[21]
* NET   433 = mem_la_wdata[20]
* NET   434 = mem_la_wdata[2]
* NET   435 = mem_la_wdata[19]
* NET   436 = mem_la_wdata[18]
* NET   437 = mem_la_wdata[17]
* NET   438 = mem_la_wdata[16]
* NET   439 = mem_la_wdata[15]
* NET   440 = mem_la_wdata[14]
* NET   441 = mem_la_wdata[13]
* NET   442 = mem_la_wdata[12]
* NET   443 = mem_la_wdata[11]
* NET   444 = mem_la_wdata[10]
* NET   445 = mem_la_wdata[1]
* NET   446 = mem_la_wdata[0]
* NET   447 = mem_la_read
* NET   448 = mem_la_addr[9]
* NET   449 = mem_la_addr[8]
* NET   450 = mem_la_addr[7]
* NET   451 = mem_la_addr[6]
* NET   452 = mem_la_addr[5]
* NET   453 = mem_la_addr[4]
* NET   454 = mem_la_addr[31]
* NET   455 = mem_la_addr[30]
* NET   456 = mem_la_addr[3]
* NET   457 = mem_la_addr[29]
* NET   458 = mem_la_addr[28]
* NET   459 = mem_la_addr[27]
* NET   460 = mem_la_addr[26]
* NET   461 = mem_la_addr[25]
* NET   462 = mem_la_addr[24]
* NET   463 = mem_la_addr[23]
* NET   464 = mem_la_addr[22]
* NET   465 = mem_la_addr[21]
* NET   466 = mem_la_addr[20]
* NET   467 = mem_la_addr[2]
* NET   468 = mem_la_addr[19]
* NET   469 = mem_la_addr[18]
* NET   470 = mem_la_addr[17]
* NET   471 = mem_la_addr[16]
* NET   472 = mem_la_addr[15]
* NET   473 = mem_la_addr[14]
* NET   474 = mem_la_addr[13]
* NET   475 = mem_la_addr[12]
* NET   476 = mem_la_addr[11]
* NET   477 = mem_la_addr[10]
* NET   478 = mem_la_addr[1]
* NET   479 = mem_la_addr[0]
* NET   480 = mem_instr
* NET   481 = mem_do_wdata
* NET   482 = mem_do_rinst
* NET   483 = mem_do_rdata
* NET   484 = mem_do_prefetch
* NET   485 = mem_addr[9]
* NET   486 = mem_addr[8]
* NET   487 = mem_addr[7]
* NET   488 = mem_addr[6]
* NET   489 = mem_addr[5]
* NET   490 = mem_addr[4]
* NET   491 = mem_addr[31]
* NET   492 = mem_addr[30]
* NET   493 = mem_addr[3]
* NET   494 = mem_addr[29]
* NET   495 = mem_addr[28]
* NET   496 = mem_addr[27]
* NET   497 = mem_addr[26]
* NET   498 = mem_addr[25]
* NET   499 = mem_addr[24]
* NET   500 = mem_addr[23]
* NET   501 = mem_addr[22]
* NET   502 = mem_addr[21]
* NET   503 = mem_addr[20]
* NET   504 = mem_addr[2]
* NET   505 = mem_addr[19]
* NET   506 = mem_addr[18]
* NET   507 = mem_addr[17]
* NET   508 = mem_addr[16]
* NET   509 = mem_addr[15]
* NET   510 = mem_addr[14]
* NET   511 = mem_addr[13]
* NET   512 = mem_addr[12]
* NET   513 = mem_addr[11]
* NET   514 = mem_addr[10]
* NET   515 = mem_addr[1]
* NET   516 = mem_addr[0]
* NET   517 = latched_store
* NET   518 = latched_stalu
* NET   519 = latched_rd[4]
* NET   520 = latched_rd[3]
* NET   521 = latched_rd[2]
* NET   522 = latched_rd[1]
* NET   523 = latched_rd[0]
* NET   524 = latched_is_lh
* NET   525 = latched_is_lb
* NET   526 = latched_branch
* NET   527 = is_sltiu_bltu_sltu
* NET   528 = is_slti_blt_slt
* NET   529 = is_slli_srli_srai
* NET   530 = is_sll_srl_sra
* NET   531 = is_sb_sh_sw
* NET   532 = is_lui_auipc_jal
* NET   533 = is_lb_lh_lw_lbu_lhu
* NET   534 = is_jalr_addi_slti_sltiu_xori_ori_andi
* NET   535 = is_compare
* NET   536 = is_beq_bne_blt_bge_bltu_bgeu
* NET   537 = is_alu_reg_reg
* NET   538 = is_alu_reg_imm
* NET   539 = irq[9]
* NET   540 = irq[8]
* NET   541 = irq[7]
* NET   542 = irq[6]
* NET   543 = irq[5]
* NET   544 = irq[4]
* NET   545 = irq[31]
* NET   546 = irq[30]
* NET   547 = irq[3]
* NET   548 = irq[29]
* NET   549 = irq[28]
* NET   550 = irq[27]
* NET   551 = irq[26]
* NET   552 = irq[25]
* NET   553 = irq[24]
* NET   554 = irq[23]
* NET   555 = irq[22]
* NET   556 = irq[21]
* NET   557 = irq[20]
* NET   558 = irq[2]
* NET   559 = irq[19]
* NET   560 = irq[18]
* NET   561 = irq[17]
* NET   562 = irq[16]
* NET   563 = irq[15]
* NET   564 = irq[14]
* NET   565 = irq[13]
* NET   566 = irq[12]
* NET   567 = irq[11]
* NET   568 = irq[10]
* NET   569 = irq[1]
* NET   570 = irq[0]
* NET   571 = instr_xori
* NET   572 = instr_xor
* NET   573 = instr_sw
* NET   574 = instr_sub
* NET   575 = instr_srli
* NET   576 = instr_srl
* NET   577 = instr_srai
* NET   578 = instr_sra
* NET   579 = instr_sltu
* NET   580 = instr_sltiu
* NET   581 = instr_slti
* NET   582 = instr_slt
* NET   583 = instr_slli
* NET   584 = instr_sll
* NET   585 = instr_sh
* NET   586 = instr_sb
* NET   587 = instr_rdinstrh
* NET   588 = instr_rdinstr
* NET   589 = instr_rdcycleh
* NET   590 = instr_rdcycle
* NET   591 = instr_ori
* NET   592 = instr_or
* NET   593 = instr_lw
* NET   594 = instr_lui
* NET   595 = instr_lhu
* NET   596 = instr_lh
* NET   597 = instr_lbu
* NET   598 = instr_lb
* NET   599 = instr_jalr
* NET   600 = instr_jal
* NET   601 = instr_bne
* NET   602 = instr_bltu
* NET   603 = instr_blt
* NET   604 = instr_bgeu
* NET   605 = instr_bge
* NET   606 = instr_beq
* NET   607 = instr_auipc
* NET   608 = instr_andi
* NET   609 = instr_and
* NET   610 = instr_addi
* NET   611 = instr_add
* NET   612 = eoi[9]
* NET   613 = eoi[8]
* NET   614 = eoi[7]
* NET   615 = eoi[6]
* NET   616 = eoi[5]
* NET   617 = eoi[4]
* NET   618 = eoi[31]
* NET   619 = eoi[30]
* NET   620 = eoi[3]
* NET   621 = eoi[29]
* NET   622 = eoi[28]
* NET   623 = eoi[27]
* NET   624 = eoi[26]
* NET   625 = eoi[25]
* NET   626 = eoi[24]
* NET   627 = eoi[23]
* NET   628 = eoi[22]
* NET   629 = eoi[21]
* NET   630 = eoi[20]
* NET   631 = eoi[2]
* NET   632 = eoi[19]
* NET   633 = eoi[18]
* NET   634 = eoi[17]
* NET   635 = eoi[16]
* NET   636 = eoi[15]
* NET   637 = eoi[14]
* NET   638 = eoi[13]
* NET   639 = eoi[12]
* NET   640 = eoi[11]
* NET   641 = eoi[10]
* NET   642 = eoi[1]
* NET   643 = eoi[0]
* NET   644 = decoder_trigger
* NET   645 = decoder_pseudo_trigger
* NET   646 = decoded_rs2[3]
* NET   647 = decoded_rs2[2]
* NET   648 = decoded_rs2[1]
* NET   649 = decoded_rs2[0]
* NET   650 = decoded_rs1[3]
* NET   651 = decoded_rs1[2]
* NET   652 = decoded_rs1[1]
* NET   653 = decoded_rs1[0]
* NET   654 = decoded_rd[4]
* NET   655 = decoded_rd[3]
* NET   656 = decoded_rd[2]
* NET   657 = decoded_rd[1]
* NET   658 = decoded_rd[0]
* NET   659 = decoded_imm_j[9]
* NET   660 = decoded_imm_j[8]
* NET   661 = decoded_imm_j[7]
* NET   662 = decoded_imm_j[6]
* NET   663 = decoded_imm_j[5]
* NET   664 = decoded_imm_j[4]
* NET   665 = decoded_imm_j[20]
* NET   666 = decoded_imm_j[19]
* NET   667 = decoded_imm_j[14]
* NET   668 = decoded_imm_j[13]
* NET   669 = decoded_imm_j[12]
* NET   670 = decoded_imm_j[10]
* NET   671 = decoded_imm[9]
* NET   672 = decoded_imm[8]
* NET   673 = decoded_imm[7]
* NET   674 = decoded_imm[6]
* NET   675 = decoded_imm[5]
* NET   676 = decoded_imm[4]
* NET   677 = decoded_imm[31]
* NET   678 = decoded_imm[30]
* NET   679 = decoded_imm[3]
* NET   680 = decoded_imm[29]
* NET   681 = decoded_imm[28]
* NET   682 = decoded_imm[27]
* NET   683 = decoded_imm[26]
* NET   684 = decoded_imm[25]
* NET   685 = decoded_imm[24]
* NET   686 = decoded_imm[23]
* NET   687 = decoded_imm[22]
* NET   688 = decoded_imm[21]
* NET   689 = decoded_imm[20]
* NET   690 = decoded_imm[2]
* NET   691 = decoded_imm[19]
* NET   692 = decoded_imm[18]
* NET   693 = decoded_imm[17]
* NET   694 = decoded_imm[16]
* NET   695 = decoded_imm[15]
* NET   696 = decoded_imm[14]
* NET   697 = decoded_imm[13]
* NET   698 = decoded_imm[12]
* NET   699 = decoded_imm[11]
* NET   700 = decoded_imm[10]
* NET   701 = decoded_imm[1]
* NET   702 = decoded_imm[0]
* NET   703 = cpuregs_rdreg_1_q_4
* NET   704 = cpuregs_rdreg_1_q_3
* NET   705 = cpuregs_rdreg_1_q_2
* NET   706 = cpuregs_rdreg_1_q_1
* NET   707 = cpuregs_rdreg_1_q_0
* NET   708 = cpuregs_rdreg_0_q_4
* NET   709 = cpuregs_rdreg_0_q_3
* NET   710 = cpuregs_rdreg_0_q_2
* NET   711 = cpuregs_rdreg_0_q_1
* NET   712 = cpuregs_rdreg_0_q_0
* NET   713 = cpuregs_9_9
* NET   714 = cpuregs_9_8
* NET   715 = cpuregs_9_7
* NET   716 = cpuregs_9_6
* NET   717 = cpuregs_9_5
* NET   718 = cpuregs_9_4
* NET   719 = cpuregs_9_31
* NET   720 = cpuregs_9_30
* NET   721 = cpuregs_9_3
* NET   722 = cpuregs_9_29
* NET   723 = cpuregs_9_28
* NET   724 = cpuregs_9_27
* NET   725 = cpuregs_9_26
* NET   726 = cpuregs_9_25
* NET   727 = cpuregs_9_24
* NET   728 = cpuregs_9_23
* NET   729 = cpuregs_9_22
* NET   730 = cpuregs_9_21
* NET   731 = cpuregs_9_20
* NET   732 = cpuregs_9_2
* NET   733 = cpuregs_9_19
* NET   734 = cpuregs_9_18
* NET   735 = cpuregs_9_17
* NET   736 = cpuregs_9_16
* NET   737 = cpuregs_9_15
* NET   738 = cpuregs_9_14
* NET   739 = cpuregs_9_13
* NET   740 = cpuregs_9_12
* NET   741 = cpuregs_9_11
* NET   742 = cpuregs_9_10
* NET   743 = cpuregs_9_1
* NET   744 = cpuregs_9_0
* NET   745 = cpuregs_8_9
* NET   746 = cpuregs_8_8
* NET   747 = cpuregs_8_7
* NET   748 = cpuregs_8_6
* NET   749 = cpuregs_8_5
* NET   750 = cpuregs_8_4
* NET   751 = cpuregs_8_31
* NET   752 = cpuregs_8_30
* NET   753 = cpuregs_8_3
* NET   754 = cpuregs_8_29
* NET   755 = cpuregs_8_28
* NET   756 = cpuregs_8_27
* NET   757 = cpuregs_8_26
* NET   758 = cpuregs_8_25
* NET   759 = cpuregs_8_24
* NET   760 = cpuregs_8_23
* NET   761 = cpuregs_8_22
* NET   762 = cpuregs_8_21
* NET   763 = cpuregs_8_20
* NET   764 = cpuregs_8_2
* NET   765 = cpuregs_8_19
* NET   766 = cpuregs_8_18
* NET   767 = cpuregs_8_17
* NET   768 = cpuregs_8_16
* NET   769 = cpuregs_8_15
* NET   770 = cpuregs_8_14
* NET   771 = cpuregs_8_13
* NET   772 = cpuregs_8_12
* NET   773 = cpuregs_8_11
* NET   774 = cpuregs_8_10
* NET   775 = cpuregs_8_1
* NET   776 = cpuregs_8_0
* NET   777 = cpuregs_7_9
* NET   778 = cpuregs_7_8
* NET   779 = cpuregs_7_7
* NET   780 = cpuregs_7_6
* NET   781 = cpuregs_7_5
* NET   782 = cpuregs_7_4
* NET   783 = cpuregs_7_31
* NET   784 = cpuregs_7_30
* NET   785 = cpuregs_7_3
* NET   786 = cpuregs_7_29
* NET   787 = cpuregs_7_28
* NET   788 = cpuregs_7_27
* NET   789 = cpuregs_7_26
* NET   790 = cpuregs_7_25
* NET   791 = cpuregs_7_24
* NET   792 = cpuregs_7_23
* NET   793 = cpuregs_7_22
* NET   794 = cpuregs_7_21
* NET   795 = cpuregs_7_20
* NET   796 = cpuregs_7_2
* NET   797 = cpuregs_7_19
* NET   798 = cpuregs_7_18
* NET   799 = cpuregs_7_17
* NET   800 = cpuregs_7_16
* NET   801 = cpuregs_7_15
* NET   802 = cpuregs_7_14
* NET   803 = cpuregs_7_13
* NET   804 = cpuregs_7_12
* NET   805 = cpuregs_7_11
* NET   806 = cpuregs_7_10
* NET   807 = cpuregs_7_1
* NET   808 = cpuregs_7_0
* NET   809 = cpuregs_6_9
* NET   810 = cpuregs_6_8
* NET   811 = cpuregs_6_7
* NET   812 = cpuregs_6_6
* NET   813 = cpuregs_6_5
* NET   814 = cpuregs_6_4
* NET   815 = cpuregs_6_31
* NET   816 = cpuregs_6_30
* NET   817 = cpuregs_6_3
* NET   818 = cpuregs_6_29
* NET   819 = cpuregs_6_28
* NET   820 = cpuregs_6_27
* NET   821 = cpuregs_6_26
* NET   822 = cpuregs_6_25
* NET   823 = cpuregs_6_24
* NET   824 = cpuregs_6_23
* NET   825 = cpuregs_6_22
* NET   826 = cpuregs_6_21
* NET   827 = cpuregs_6_20
* NET   828 = cpuregs_6_2
* NET   829 = cpuregs_6_19
* NET   830 = cpuregs_6_18
* NET   831 = cpuregs_6_17
* NET   832 = cpuregs_6_16
* NET   833 = cpuregs_6_15
* NET   834 = cpuregs_6_14
* NET   835 = cpuregs_6_13
* NET   836 = cpuregs_6_12
* NET   837 = cpuregs_6_11
* NET   838 = cpuregs_6_10
* NET   839 = cpuregs_6_1
* NET   840 = cpuregs_6_0
* NET   841 = cpuregs_5_9
* NET   842 = cpuregs_5_8
* NET   843 = cpuregs_5_7
* NET   844 = cpuregs_5_6
* NET   845 = cpuregs_5_5
* NET   846 = cpuregs_5_4
* NET   847 = cpuregs_5_31
* NET   848 = cpuregs_5_30
* NET   849 = cpuregs_5_3
* NET   850 = cpuregs_5_29
* NET   851 = cpuregs_5_28
* NET   852 = cpuregs_5_27
* NET   853 = cpuregs_5_26
* NET   854 = cpuregs_5_25
* NET   855 = cpuregs_5_24
* NET   856 = cpuregs_5_23
* NET   857 = cpuregs_5_22
* NET   858 = cpuregs_5_21
* NET   859 = cpuregs_5_20
* NET   860 = cpuregs_5_2
* NET   861 = cpuregs_5_19
* NET   862 = cpuregs_5_18
* NET   863 = cpuregs_5_17
* NET   864 = cpuregs_5_16
* NET   865 = cpuregs_5_15
* NET   866 = cpuregs_5_14
* NET   867 = cpuregs_5_13
* NET   868 = cpuregs_5_12
* NET   869 = cpuregs_5_11
* NET   870 = cpuregs_5_10
* NET   871 = cpuregs_5_1
* NET   872 = cpuregs_5_0
* NET   873 = cpuregs_4_9
* NET   874 = cpuregs_4_8
* NET   875 = cpuregs_4_7
* NET   876 = cpuregs_4_6
* NET   877 = cpuregs_4_5
* NET   878 = cpuregs_4_4
* NET   879 = cpuregs_4_31
* NET   880 = cpuregs_4_30
* NET   881 = cpuregs_4_3
* NET   882 = cpuregs_4_29
* NET   883 = cpuregs_4_28
* NET   884 = cpuregs_4_27
* NET   885 = cpuregs_4_26
* NET   886 = cpuregs_4_25
* NET   887 = cpuregs_4_24
* NET   888 = cpuregs_4_23
* NET   889 = cpuregs_4_22
* NET   890 = cpuregs_4_21
* NET   891 = cpuregs_4_20
* NET   892 = cpuregs_4_2
* NET   893 = cpuregs_4_19
* NET   894 = cpuregs_4_18
* NET   895 = cpuregs_4_17
* NET   896 = cpuregs_4_16
* NET   897 = cpuregs_4_15
* NET   898 = cpuregs_4_14
* NET   899 = cpuregs_4_13
* NET   900 = cpuregs_4_12
* NET   901 = cpuregs_4_11
* NET   902 = cpuregs_4_10
* NET   903 = cpuregs_4_1
* NET   904 = cpuregs_4_0
* NET   905 = cpuregs_3_9
* NET   906 = cpuregs_3_8
* NET   907 = cpuregs_3_7
* NET   908 = cpuregs_3_6
* NET   909 = cpuregs_3_5
* NET   910 = cpuregs_3_4
* NET   911 = cpuregs_3_31
* NET   912 = cpuregs_3_30
* NET   913 = cpuregs_3_3
* NET   914 = cpuregs_3_29
* NET   915 = cpuregs_3_28
* NET   916 = cpuregs_3_27
* NET   917 = cpuregs_3_26
* NET   918 = cpuregs_3_25
* NET   919 = cpuregs_3_24
* NET   920 = cpuregs_3_23
* NET   921 = cpuregs_3_22
* NET   922 = cpuregs_3_21
* NET   923 = cpuregs_3_20
* NET   924 = cpuregs_3_2
* NET   925 = cpuregs_3_19
* NET   926 = cpuregs_3_18
* NET   927 = cpuregs_3_17
* NET   928 = cpuregs_3_16
* NET   929 = cpuregs_3_15
* NET   930 = cpuregs_3_14
* NET   931 = cpuregs_3_13
* NET   932 = cpuregs_3_12
* NET   933 = cpuregs_3_11
* NET   934 = cpuregs_3_10
* NET   935 = cpuregs_3_1
* NET   936 = cpuregs_3_0
* NET   937 = cpuregs_31_9
* NET   938 = cpuregs_31_8
* NET   939 = cpuregs_31_7
* NET   940 = cpuregs_31_6
* NET   941 = cpuregs_31_5
* NET   942 = cpuregs_31_4
* NET   943 = cpuregs_31_31
* NET   944 = cpuregs_31_30
* NET   945 = cpuregs_31_3
* NET   946 = cpuregs_31_29
* NET   947 = cpuregs_31_28
* NET   948 = cpuregs_31_27
* NET   949 = cpuregs_31_26
* NET   950 = cpuregs_31_25
* NET   951 = cpuregs_31_24
* NET   952 = cpuregs_31_23
* NET   953 = cpuregs_31_22
* NET   954 = cpuregs_31_21
* NET   955 = cpuregs_31_20
* NET   956 = cpuregs_31_2
* NET   957 = cpuregs_31_19
* NET   958 = cpuregs_31_18
* NET   959 = cpuregs_31_17
* NET   960 = cpuregs_31_16
* NET   961 = cpuregs_31_15
* NET   962 = cpuregs_31_14
* NET   963 = cpuregs_31_13
* NET   964 = cpuregs_31_12
* NET   965 = cpuregs_31_11
* NET   966 = cpuregs_31_10
* NET   967 = cpuregs_31_1
* NET   968 = cpuregs_31_0
* NET   969 = cpuregs_30_9
* NET   970 = cpuregs_30_8
* NET   971 = cpuregs_30_7
* NET   972 = cpuregs_30_6
* NET   973 = cpuregs_30_5
* NET   974 = cpuregs_30_4
* NET   975 = cpuregs_30_31
* NET   976 = cpuregs_30_30
* NET   977 = cpuregs_30_3
* NET   978 = cpuregs_30_29
* NET   979 = cpuregs_30_28
* NET   980 = cpuregs_30_27
* NET   981 = cpuregs_30_26
* NET   982 = cpuregs_30_25
* NET   983 = cpuregs_30_24
* NET   984 = cpuregs_30_23
* NET   985 = cpuregs_30_22
* NET   986 = cpuregs_30_21
* NET   987 = cpuregs_30_20
* NET   988 = cpuregs_30_2
* NET   989 = cpuregs_30_19
* NET   990 = cpuregs_30_18
* NET   991 = cpuregs_30_17
* NET   992 = cpuregs_30_16
* NET   993 = cpuregs_30_15
* NET   994 = cpuregs_30_14
* NET   995 = cpuregs_30_13
* NET   996 = cpuregs_30_12
* NET   997 = cpuregs_30_11
* NET   998 = cpuregs_30_10
* NET   999 = cpuregs_30_1
* NET  1000 = cpuregs_30_0
* NET  1001 = cpuregs_2_9
* NET  1002 = cpuregs_2_8
* NET  1003 = cpuregs_2_7
* NET  1004 = cpuregs_2_6
* NET  1005 = cpuregs_2_5
* NET  1006 = cpuregs_2_4
* NET  1007 = cpuregs_2_31
* NET  1008 = cpuregs_2_30
* NET  1009 = cpuregs_2_3
* NET  1010 = cpuregs_2_29
* NET  1011 = cpuregs_2_28
* NET  1012 = cpuregs_2_27
* NET  1013 = cpuregs_2_26
* NET  1014 = cpuregs_2_25
* NET  1015 = cpuregs_2_24
* NET  1016 = cpuregs_2_23
* NET  1017 = cpuregs_2_22
* NET  1018 = cpuregs_2_21
* NET  1019 = cpuregs_2_20
* NET  1020 = cpuregs_2_2
* NET  1021 = cpuregs_2_19
* NET  1022 = cpuregs_2_18
* NET  1023 = cpuregs_2_17
* NET  1024 = cpuregs_2_16
* NET  1025 = cpuregs_2_15
* NET  1026 = cpuregs_2_14
* NET  1027 = cpuregs_2_13
* NET  1028 = cpuregs_2_12
* NET  1029 = cpuregs_2_11
* NET  1030 = cpuregs_2_10
* NET  1031 = cpuregs_2_1
* NET  1032 = cpuregs_2_0
* NET  1033 = cpuregs_29_9
* NET  1034 = cpuregs_29_8
* NET  1035 = cpuregs_29_7
* NET  1036 = cpuregs_29_6
* NET  1037 = cpuregs_29_5
* NET  1038 = cpuregs_29_4
* NET  1039 = cpuregs_29_31
* NET  1040 = cpuregs_29_30
* NET  1041 = cpuregs_29_3
* NET  1042 = cpuregs_29_29
* NET  1043 = cpuregs_29_28
* NET  1044 = cpuregs_29_27
* NET  1045 = cpuregs_29_26
* NET  1046 = cpuregs_29_25
* NET  1047 = cpuregs_29_24
* NET  1048 = cpuregs_29_23
* NET  1049 = cpuregs_29_22
* NET  1050 = cpuregs_29_21
* NET  1051 = cpuregs_29_20
* NET  1052 = cpuregs_29_2
* NET  1053 = cpuregs_29_19
* NET  1054 = cpuregs_29_18
* NET  1055 = cpuregs_29_17
* NET  1056 = cpuregs_29_16
* NET  1057 = cpuregs_29_15
* NET  1058 = cpuregs_29_14
* NET  1059 = cpuregs_29_13
* NET  1060 = cpuregs_29_12
* NET  1061 = cpuregs_29_11
* NET  1062 = cpuregs_29_10
* NET  1063 = cpuregs_29_1
* NET  1064 = cpuregs_29_0
* NET  1065 = cpuregs_28_9
* NET  1066 = cpuregs_28_8
* NET  1067 = cpuregs_28_7
* NET  1068 = cpuregs_28_6
* NET  1069 = cpuregs_28_5
* NET  1070 = cpuregs_28_4
* NET  1071 = cpuregs_28_31
* NET  1072 = cpuregs_28_30
* NET  1073 = cpuregs_28_3
* NET  1074 = cpuregs_28_29
* NET  1075 = cpuregs_28_28
* NET  1076 = cpuregs_28_27
* NET  1077 = cpuregs_28_26
* NET  1078 = cpuregs_28_25
* NET  1079 = cpuregs_28_24
* NET  1080 = cpuregs_28_23
* NET  1081 = cpuregs_28_22
* NET  1082 = cpuregs_28_21
* NET  1083 = cpuregs_28_20
* NET  1084 = cpuregs_28_2
* NET  1085 = cpuregs_28_19
* NET  1086 = cpuregs_28_18
* NET  1087 = cpuregs_28_17
* NET  1088 = cpuregs_28_16
* NET  1089 = cpuregs_28_15
* NET  1090 = cpuregs_28_14
* NET  1091 = cpuregs_28_13
* NET  1092 = cpuregs_28_12
* NET  1093 = cpuregs_28_11
* NET  1094 = cpuregs_28_10
* NET  1095 = cpuregs_28_1
* NET  1096 = cpuregs_28_0
* NET  1097 = cpuregs_27_9
* NET  1098 = cpuregs_27_8
* NET  1099 = cpuregs_27_7
* NET  1100 = cpuregs_27_6
* NET  1101 = cpuregs_27_5
* NET  1102 = cpuregs_27_4
* NET  1103 = cpuregs_27_31
* NET  1104 = cpuregs_27_30
* NET  1105 = cpuregs_27_3
* NET  1106 = cpuregs_27_29
* NET  1107 = cpuregs_27_28
* NET  1108 = cpuregs_27_27
* NET  1109 = cpuregs_27_26
* NET  1110 = cpuregs_27_25
* NET  1111 = cpuregs_27_24
* NET  1112 = cpuregs_27_23
* NET  1113 = cpuregs_27_22
* NET  1114 = cpuregs_27_21
* NET  1115 = cpuregs_27_20
* NET  1116 = cpuregs_27_2
* NET  1117 = cpuregs_27_19
* NET  1118 = cpuregs_27_18
* NET  1119 = cpuregs_27_17
* NET  1120 = cpuregs_27_16
* NET  1121 = cpuregs_27_15
* NET  1122 = cpuregs_27_14
* NET  1123 = cpuregs_27_13
* NET  1124 = cpuregs_27_12
* NET  1125 = cpuregs_27_11
* NET  1126 = cpuregs_27_10
* NET  1127 = cpuregs_27_1
* NET  1128 = cpuregs_27_0
* NET  1129 = cpuregs_26_9
* NET  1130 = cpuregs_26_8
* NET  1131 = cpuregs_26_7
* NET  1132 = cpuregs_26_6
* NET  1133 = cpuregs_26_5
* NET  1134 = cpuregs_26_4
* NET  1135 = cpuregs_26_31
* NET  1136 = cpuregs_26_30
* NET  1137 = cpuregs_26_3
* NET  1138 = cpuregs_26_29
* NET  1139 = cpuregs_26_28
* NET  1140 = cpuregs_26_27
* NET  1141 = cpuregs_26_26
* NET  1142 = cpuregs_26_25
* NET  1143 = cpuregs_26_24
* NET  1144 = cpuregs_26_23
* NET  1145 = cpuregs_26_22
* NET  1146 = cpuregs_26_21
* NET  1147 = cpuregs_26_20
* NET  1148 = cpuregs_26_2
* NET  1149 = cpuregs_26_19
* NET  1150 = cpuregs_26_18
* NET  1151 = cpuregs_26_17
* NET  1152 = cpuregs_26_16
* NET  1153 = cpuregs_26_15
* NET  1154 = cpuregs_26_14
* NET  1155 = cpuregs_26_13
* NET  1156 = cpuregs_26_12
* NET  1157 = cpuregs_26_11
* NET  1158 = cpuregs_26_10
* NET  1159 = cpuregs_26_1
* NET  1160 = cpuregs_26_0
* NET  1161 = cpuregs_25_9
* NET  1162 = cpuregs_25_8
* NET  1163 = cpuregs_25_7
* NET  1164 = cpuregs_25_6
* NET  1165 = cpuregs_25_5
* NET  1166 = cpuregs_25_4
* NET  1167 = cpuregs_25_31
* NET  1168 = cpuregs_25_30
* NET  1169 = cpuregs_25_3
* NET  1170 = cpuregs_25_29
* NET  1171 = cpuregs_25_28
* NET  1172 = cpuregs_25_27
* NET  1173 = cpuregs_25_26
* NET  1174 = cpuregs_25_25
* NET  1175 = cpuregs_25_24
* NET  1176 = cpuregs_25_23
* NET  1177 = cpuregs_25_22
* NET  1178 = cpuregs_25_21
* NET  1179 = cpuregs_25_20
* NET  1180 = cpuregs_25_2
* NET  1181 = cpuregs_25_19
* NET  1182 = cpuregs_25_18
* NET  1183 = cpuregs_25_17
* NET  1184 = cpuregs_25_16
* NET  1185 = cpuregs_25_15
* NET  1186 = cpuregs_25_14
* NET  1187 = cpuregs_25_13
* NET  1188 = cpuregs_25_12
* NET  1189 = cpuregs_25_11
* NET  1190 = cpuregs_25_10
* NET  1191 = cpuregs_25_1
* NET  1192 = cpuregs_25_0
* NET  1193 = cpuregs_24_9
* NET  1194 = cpuregs_24_8
* NET  1195 = cpuregs_24_7
* NET  1196 = cpuregs_24_6
* NET  1197 = cpuregs_24_5
* NET  1198 = cpuregs_24_4
* NET  1199 = cpuregs_24_31
* NET  1200 = cpuregs_24_30
* NET  1201 = cpuregs_24_3
* NET  1202 = cpuregs_24_29
* NET  1203 = cpuregs_24_28
* NET  1204 = cpuregs_24_27
* NET  1205 = cpuregs_24_26
* NET  1206 = cpuregs_24_25
* NET  1207 = cpuregs_24_24
* NET  1208 = cpuregs_24_23
* NET  1209 = cpuregs_24_22
* NET  1210 = cpuregs_24_21
* NET  1211 = cpuregs_24_20
* NET  1212 = cpuregs_24_2
* NET  1213 = cpuregs_24_19
* NET  1214 = cpuregs_24_18
* NET  1215 = cpuregs_24_17
* NET  1216 = cpuregs_24_16
* NET  1217 = cpuregs_24_15
* NET  1218 = cpuregs_24_14
* NET  1219 = cpuregs_24_13
* NET  1220 = cpuregs_24_12
* NET  1221 = cpuregs_24_11
* NET  1222 = cpuregs_24_10
* NET  1223 = cpuregs_24_1
* NET  1224 = cpuregs_24_0
* NET  1225 = cpuregs_23_9
* NET  1226 = cpuregs_23_8
* NET  1227 = cpuregs_23_7
* NET  1228 = cpuregs_23_6
* NET  1229 = cpuregs_23_5
* NET  1230 = cpuregs_23_4
* NET  1231 = cpuregs_23_31
* NET  1232 = cpuregs_23_30
* NET  1233 = cpuregs_23_3
* NET  1234 = cpuregs_23_29
* NET  1235 = cpuregs_23_28
* NET  1236 = cpuregs_23_27
* NET  1237 = cpuregs_23_26
* NET  1238 = cpuregs_23_25
* NET  1239 = cpuregs_23_24
* NET  1240 = cpuregs_23_23
* NET  1241 = cpuregs_23_22
* NET  1242 = cpuregs_23_21
* NET  1243 = cpuregs_23_20
* NET  1244 = cpuregs_23_2
* NET  1245 = cpuregs_23_19
* NET  1246 = cpuregs_23_18
* NET  1247 = cpuregs_23_17
* NET  1248 = cpuregs_23_16
* NET  1249 = cpuregs_23_15
* NET  1250 = cpuregs_23_14
* NET  1251 = cpuregs_23_13
* NET  1252 = cpuregs_23_12
* NET  1253 = cpuregs_23_11
* NET  1254 = cpuregs_23_10
* NET  1255 = cpuregs_23_1
* NET  1256 = cpuregs_23_0
* NET  1257 = cpuregs_22_9
* NET  1258 = cpuregs_22_8
* NET  1259 = cpuregs_22_7
* NET  1260 = cpuregs_22_6
* NET  1261 = cpuregs_22_5
* NET  1262 = cpuregs_22_4
* NET  1263 = cpuregs_22_31
* NET  1264 = cpuregs_22_30
* NET  1265 = cpuregs_22_3
* NET  1266 = cpuregs_22_29
* NET  1267 = cpuregs_22_28
* NET  1268 = cpuregs_22_27
* NET  1269 = cpuregs_22_26
* NET  1270 = cpuregs_22_25
* NET  1271 = cpuregs_22_24
* NET  1272 = cpuregs_22_23
* NET  1273 = cpuregs_22_22
* NET  1274 = cpuregs_22_21
* NET  1275 = cpuregs_22_20
* NET  1276 = cpuregs_22_2
* NET  1277 = cpuregs_22_19
* NET  1278 = cpuregs_22_18
* NET  1279 = cpuregs_22_17
* NET  1280 = cpuregs_22_16
* NET  1281 = cpuregs_22_15
* NET  1282 = cpuregs_22_14
* NET  1283 = cpuregs_22_13
* NET  1284 = cpuregs_22_12
* NET  1285 = cpuregs_22_11
* NET  1286 = cpuregs_22_10
* NET  1287 = cpuregs_22_1
* NET  1288 = cpuregs_22_0
* NET  1289 = cpuregs_21_9
* NET  1290 = cpuregs_21_8
* NET  1291 = cpuregs_21_7
* NET  1292 = cpuregs_21_6
* NET  1293 = cpuregs_21_5
* NET  1294 = cpuregs_21_4
* NET  1295 = cpuregs_21_31
* NET  1296 = cpuregs_21_30
* NET  1297 = cpuregs_21_3
* NET  1298 = cpuregs_21_29
* NET  1299 = cpuregs_21_28
* NET  1300 = cpuregs_21_27
* NET  1301 = cpuregs_21_26
* NET  1302 = cpuregs_21_25
* NET  1303 = cpuregs_21_24
* NET  1304 = cpuregs_21_23
* NET  1305 = cpuregs_21_22
* NET  1306 = cpuregs_21_21
* NET  1307 = cpuregs_21_20
* NET  1308 = cpuregs_21_2
* NET  1309 = cpuregs_21_19
* NET  1310 = cpuregs_21_18
* NET  1311 = cpuregs_21_17
* NET  1312 = cpuregs_21_16
* NET  1313 = cpuregs_21_15
* NET  1314 = cpuregs_21_14
* NET  1315 = cpuregs_21_13
* NET  1316 = cpuregs_21_12
* NET  1317 = cpuregs_21_11
* NET  1318 = cpuregs_21_10
* NET  1319 = cpuregs_21_1
* NET  1320 = cpuregs_21_0
* NET  1321 = cpuregs_20_9
* NET  1322 = cpuregs_20_8
* NET  1323 = cpuregs_20_7
* NET  1324 = cpuregs_20_6
* NET  1325 = cpuregs_20_5
* NET  1326 = cpuregs_20_4
* NET  1327 = cpuregs_20_31
* NET  1328 = cpuregs_20_30
* NET  1329 = cpuregs_20_3
* NET  1330 = cpuregs_20_29
* NET  1331 = cpuregs_20_28
* NET  1332 = cpuregs_20_27
* NET  1333 = cpuregs_20_26
* NET  1334 = cpuregs_20_25
* NET  1335 = cpuregs_20_24
* NET  1336 = cpuregs_20_23
* NET  1337 = cpuregs_20_22
* NET  1338 = cpuregs_20_21
* NET  1339 = cpuregs_20_20
* NET  1340 = cpuregs_20_2
* NET  1341 = cpuregs_20_19
* NET  1342 = cpuregs_20_18
* NET  1343 = cpuregs_20_17
* NET  1344 = cpuregs_20_16
* NET  1345 = cpuregs_20_15
* NET  1346 = cpuregs_20_14
* NET  1347 = cpuregs_20_13
* NET  1348 = cpuregs_20_12
* NET  1349 = cpuregs_20_11
* NET  1350 = cpuregs_20_10
* NET  1351 = cpuregs_20_1
* NET  1352 = cpuregs_20_0
* NET  1353 = cpuregs_1_9
* NET  1354 = cpuregs_1_8
* NET  1355 = cpuregs_1_7
* NET  1356 = cpuregs_1_6
* NET  1357 = cpuregs_1_5
* NET  1358 = cpuregs_1_4
* NET  1359 = cpuregs_1_31
* NET  1360 = cpuregs_1_30
* NET  1361 = cpuregs_1_3
* NET  1362 = cpuregs_1_29
* NET  1363 = cpuregs_1_28
* NET  1364 = cpuregs_1_27
* NET  1365 = cpuregs_1_26
* NET  1366 = cpuregs_1_25
* NET  1367 = cpuregs_1_24
* NET  1368 = cpuregs_1_23
* NET  1369 = cpuregs_1_22
* NET  1370 = cpuregs_1_21
* NET  1371 = cpuregs_1_20
* NET  1372 = cpuregs_1_2
* NET  1373 = cpuregs_1_19
* NET  1374 = cpuregs_1_18
* NET  1375 = cpuregs_1_17
* NET  1376 = cpuregs_1_16
* NET  1377 = cpuregs_1_15
* NET  1378 = cpuregs_1_14
* NET  1379 = cpuregs_1_13
* NET  1380 = cpuregs_1_12
* NET  1381 = cpuregs_1_11
* NET  1382 = cpuregs_1_10
* NET  1383 = cpuregs_1_1
* NET  1384 = cpuregs_1_0
* NET  1385 = cpuregs_19_9
* NET  1386 = cpuregs_19_8
* NET  1387 = cpuregs_19_7
* NET  1388 = cpuregs_19_6
* NET  1389 = cpuregs_19_5
* NET  1390 = cpuregs_19_4
* NET  1391 = cpuregs_19_31
* NET  1392 = cpuregs_19_30
* NET  1393 = cpuregs_19_3
* NET  1394 = cpuregs_19_29
* NET  1395 = cpuregs_19_28
* NET  1396 = cpuregs_19_27
* NET  1397 = cpuregs_19_26
* NET  1398 = cpuregs_19_25
* NET  1399 = cpuregs_19_24
* NET  1400 = cpuregs_19_23
* NET  1401 = cpuregs_19_22
* NET  1402 = cpuregs_19_21
* NET  1403 = cpuregs_19_20
* NET  1404 = cpuregs_19_2
* NET  1405 = cpuregs_19_19
* NET  1406 = cpuregs_19_18
* NET  1407 = cpuregs_19_17
* NET  1408 = cpuregs_19_16
* NET  1409 = cpuregs_19_15
* NET  1410 = cpuregs_19_14
* NET  1411 = cpuregs_19_13
* NET  1412 = cpuregs_19_12
* NET  1413 = cpuregs_19_11
* NET  1414 = cpuregs_19_10
* NET  1415 = cpuregs_19_1
* NET  1416 = cpuregs_19_0
* NET  1417 = cpuregs_18_9
* NET  1418 = cpuregs_18_8
* NET  1419 = cpuregs_18_7
* NET  1420 = cpuregs_18_6
* NET  1421 = cpuregs_18_5
* NET  1422 = cpuregs_18_4
* NET  1423 = cpuregs_18_31
* NET  1424 = cpuregs_18_30
* NET  1425 = cpuregs_18_3
* NET  1426 = cpuregs_18_29
* NET  1427 = cpuregs_18_28
* NET  1428 = cpuregs_18_27
* NET  1429 = cpuregs_18_26
* NET  1430 = cpuregs_18_25
* NET  1431 = cpuregs_18_24
* NET  1432 = cpuregs_18_23
* NET  1433 = cpuregs_18_22
* NET  1434 = cpuregs_18_21
* NET  1435 = cpuregs_18_20
* NET  1436 = cpuregs_18_2
* NET  1437 = cpuregs_18_19
* NET  1438 = cpuregs_18_18
* NET  1439 = cpuregs_18_17
* NET  1440 = cpuregs_18_16
* NET  1441 = cpuregs_18_15
* NET  1442 = cpuregs_18_14
* NET  1443 = cpuregs_18_13
* NET  1444 = cpuregs_18_12
* NET  1445 = cpuregs_18_11
* NET  1446 = cpuregs_18_10
* NET  1447 = cpuregs_18_1
* NET  1448 = cpuregs_18_0
* NET  1449 = cpuregs_17_9
* NET  1450 = cpuregs_17_8
* NET  1451 = cpuregs_17_7
* NET  1452 = cpuregs_17_6
* NET  1453 = cpuregs_17_5
* NET  1454 = cpuregs_17_4
* NET  1455 = cpuregs_17_31
* NET  1456 = cpuregs_17_30
* NET  1457 = cpuregs_17_3
* NET  1458 = cpuregs_17_29
* NET  1459 = cpuregs_17_28
* NET  1460 = cpuregs_17_27
* NET  1461 = cpuregs_17_26
* NET  1462 = cpuregs_17_25
* NET  1463 = cpuregs_17_24
* NET  1464 = cpuregs_17_23
* NET  1465 = cpuregs_17_22
* NET  1466 = cpuregs_17_21
* NET  1467 = cpuregs_17_20
* NET  1468 = cpuregs_17_2
* NET  1469 = cpuregs_17_19
* NET  1470 = cpuregs_17_18
* NET  1471 = cpuregs_17_17
* NET  1472 = cpuregs_17_16
* NET  1473 = cpuregs_17_15
* NET  1474 = cpuregs_17_14
* NET  1475 = cpuregs_17_13
* NET  1476 = cpuregs_17_12
* NET  1477 = cpuregs_17_11
* NET  1478 = cpuregs_17_10
* NET  1479 = cpuregs_17_1
* NET  1480 = cpuregs_17_0
* NET  1481 = cpuregs_16_9
* NET  1482 = cpuregs_16_8
* NET  1483 = cpuregs_16_7
* NET  1484 = cpuregs_16_6
* NET  1485 = cpuregs_16_5
* NET  1486 = cpuregs_16_4
* NET  1487 = cpuregs_16_31
* NET  1488 = cpuregs_16_30
* NET  1489 = cpuregs_16_3
* NET  1490 = cpuregs_16_29
* NET  1491 = cpuregs_16_28
* NET  1492 = cpuregs_16_27
* NET  1493 = cpuregs_16_26
* NET  1494 = cpuregs_16_25
* NET  1495 = cpuregs_16_24
* NET  1496 = cpuregs_16_23
* NET  1497 = cpuregs_16_22
* NET  1498 = cpuregs_16_21
* NET  1499 = cpuregs_16_20
* NET  1500 = cpuregs_16_2
* NET  1501 = cpuregs_16_19
* NET  1502 = cpuregs_16_18
* NET  1503 = cpuregs_16_17
* NET  1504 = cpuregs_16_16
* NET  1505 = cpuregs_16_15
* NET  1506 = cpuregs_16_14
* NET  1507 = cpuregs_16_13
* NET  1508 = cpuregs_16_12
* NET  1509 = cpuregs_16_11
* NET  1510 = cpuregs_16_10
* NET  1511 = cpuregs_16_1
* NET  1512 = cpuregs_16_0
* NET  1513 = cpuregs_15_9
* NET  1514 = cpuregs_15_8
* NET  1515 = cpuregs_15_7
* NET  1516 = cpuregs_15_6
* NET  1517 = cpuregs_15_5
* NET  1518 = cpuregs_15_4
* NET  1519 = cpuregs_15_31
* NET  1520 = cpuregs_15_30
* NET  1521 = cpuregs_15_3
* NET  1522 = cpuregs_15_29
* NET  1523 = cpuregs_15_28
* NET  1524 = cpuregs_15_27
* NET  1525 = cpuregs_15_26
* NET  1526 = cpuregs_15_25
* NET  1527 = cpuregs_15_24
* NET  1528 = cpuregs_15_23
* NET  1529 = cpuregs_15_22
* NET  1530 = cpuregs_15_21
* NET  1531 = cpuregs_15_20
* NET  1532 = cpuregs_15_2
* NET  1533 = cpuregs_15_19
* NET  1534 = cpuregs_15_18
* NET  1535 = cpuregs_15_17
* NET  1536 = cpuregs_15_16
* NET  1537 = cpuregs_15_15
* NET  1538 = cpuregs_15_14
* NET  1539 = cpuregs_15_13
* NET  1540 = cpuregs_15_12
* NET  1541 = cpuregs_15_11
* NET  1542 = cpuregs_15_10
* NET  1543 = cpuregs_15_1
* NET  1544 = cpuregs_15_0
* NET  1545 = cpuregs_14_9
* NET  1546 = cpuregs_14_8
* NET  1547 = cpuregs_14_7
* NET  1548 = cpuregs_14_6
* NET  1549 = cpuregs_14_5
* NET  1550 = cpuregs_14_4
* NET  1551 = cpuregs_14_31
* NET  1552 = cpuregs_14_30
* NET  1553 = cpuregs_14_3
* NET  1554 = cpuregs_14_29
* NET  1555 = cpuregs_14_28
* NET  1556 = cpuregs_14_27
* NET  1557 = cpuregs_14_26
* NET  1558 = cpuregs_14_25
* NET  1559 = cpuregs_14_24
* NET  1560 = cpuregs_14_23
* NET  1561 = cpuregs_14_22
* NET  1562 = cpuregs_14_21
* NET  1563 = cpuregs_14_20
* NET  1564 = cpuregs_14_2
* NET  1565 = cpuregs_14_19
* NET  1566 = cpuregs_14_18
* NET  1567 = cpuregs_14_17
* NET  1568 = cpuregs_14_16
* NET  1569 = cpuregs_14_15
* NET  1570 = cpuregs_14_14
* NET  1571 = cpuregs_14_13
* NET  1572 = cpuregs_14_12
* NET  1573 = cpuregs_14_11
* NET  1574 = cpuregs_14_10
* NET  1575 = cpuregs_14_1
* NET  1576 = cpuregs_14_0
* NET  1577 = cpuregs_13_9
* NET  1578 = cpuregs_13_8
* NET  1579 = cpuregs_13_7
* NET  1580 = cpuregs_13_6
* NET  1581 = cpuregs_13_5
* NET  1582 = cpuregs_13_4
* NET  1583 = cpuregs_13_31
* NET  1584 = cpuregs_13_30
* NET  1585 = cpuregs_13_3
* NET  1586 = cpuregs_13_29
* NET  1587 = cpuregs_13_28
* NET  1588 = cpuregs_13_27
* NET  1589 = cpuregs_13_26
* NET  1590 = cpuregs_13_25
* NET  1591 = cpuregs_13_24
* NET  1592 = cpuregs_13_23
* NET  1593 = cpuregs_13_22
* NET  1594 = cpuregs_13_21
* NET  1595 = cpuregs_13_20
* NET  1596 = cpuregs_13_2
* NET  1597 = cpuregs_13_19
* NET  1598 = cpuregs_13_18
* NET  1599 = cpuregs_13_17
* NET  1600 = cpuregs_13_16
* NET  1601 = cpuregs_13_15
* NET  1602 = cpuregs_13_14
* NET  1603 = cpuregs_13_13
* NET  1604 = cpuregs_13_12
* NET  1605 = cpuregs_13_11
* NET  1606 = cpuregs_13_10
* NET  1607 = cpuregs_13_1
* NET  1608 = cpuregs_13_0
* NET  1609 = cpuregs_12_9
* NET  1610 = cpuregs_12_8
* NET  1611 = cpuregs_12_7
* NET  1612 = cpuregs_12_6
* NET  1613 = cpuregs_12_5
* NET  1614 = cpuregs_12_4
* NET  1615 = cpuregs_12_31
* NET  1616 = cpuregs_12_30
* NET  1617 = cpuregs_12_3
* NET  1618 = cpuregs_12_29
* NET  1619 = cpuregs_12_28
* NET  1620 = cpuregs_12_27
* NET  1621 = cpuregs_12_26
* NET  1622 = cpuregs_12_25
* NET  1623 = cpuregs_12_24
* NET  1624 = cpuregs_12_23
* NET  1625 = cpuregs_12_22
* NET  1626 = cpuregs_12_21
* NET  1627 = cpuregs_12_20
* NET  1628 = cpuregs_12_2
* NET  1629 = cpuregs_12_19
* NET  1630 = cpuregs_12_18
* NET  1631 = cpuregs_12_17
* NET  1632 = cpuregs_12_16
* NET  1633 = cpuregs_12_15
* NET  1634 = cpuregs_12_14
* NET  1635 = cpuregs_12_13
* NET  1636 = cpuregs_12_12
* NET  1637 = cpuregs_12_11
* NET  1638 = cpuregs_12_10
* NET  1639 = cpuregs_12_1
* NET  1640 = cpuregs_12_0
* NET  1641 = cpuregs_11_9
* NET  1642 = cpuregs_11_8
* NET  1643 = cpuregs_11_7
* NET  1644 = cpuregs_11_6
* NET  1645 = cpuregs_11_5
* NET  1646 = cpuregs_11_4
* NET  1647 = cpuregs_11_31
* NET  1648 = cpuregs_11_30
* NET  1649 = cpuregs_11_3
* NET  1650 = cpuregs_11_29
* NET  1651 = cpuregs_11_28
* NET  1652 = cpuregs_11_27
* NET  1653 = cpuregs_11_26
* NET  1654 = cpuregs_11_25
* NET  1655 = cpuregs_11_24
* NET  1656 = cpuregs_11_23
* NET  1657 = cpuregs_11_22
* NET  1658 = cpuregs_11_21
* NET  1659 = cpuregs_11_20
* NET  1660 = cpuregs_11_2
* NET  1661 = cpuregs_11_19
* NET  1662 = cpuregs_11_18
* NET  1663 = cpuregs_11_17
* NET  1664 = cpuregs_11_16
* NET  1665 = cpuregs_11_15
* NET  1666 = cpuregs_11_14
* NET  1667 = cpuregs_11_13
* NET  1668 = cpuregs_11_12
* NET  1669 = cpuregs_11_11
* NET  1670 = cpuregs_11_10
* NET  1671 = cpuregs_11_1
* NET  1672 = cpuregs_11_0
* NET  1673 = cpuregs_10_9
* NET  1674 = cpuregs_10_8
* NET  1675 = cpuregs_10_7
* NET  1676 = cpuregs_10_6
* NET  1677 = cpuregs_10_5
* NET  1678 = cpuregs_10_4
* NET  1679 = cpuregs_10_31
* NET  1680 = cpuregs_10_30
* NET  1681 = cpuregs_10_3
* NET  1682 = cpuregs_10_29
* NET  1683 = cpuregs_10_28
* NET  1684 = cpuregs_10_27
* NET  1685 = cpuregs_10_26
* NET  1686 = cpuregs_10_25
* NET  1687 = cpuregs_10_24
* NET  1688 = cpuregs_10_23
* NET  1689 = cpuregs_10_22
* NET  1690 = cpuregs_10_21
* NET  1691 = cpuregs_10_20
* NET  1692 = cpuregs_10_2
* NET  1693 = cpuregs_10_19
* NET  1694 = cpuregs_10_18
* NET  1695 = cpuregs_10_17
* NET  1696 = cpuregs_10_16
* NET  1697 = cpuregs_10_15
* NET  1698 = cpuregs_10_14
* NET  1699 = cpuregs_10_13
* NET  1700 = cpuregs_10_12
* NET  1701 = cpuregs_10_11
* NET  1702 = cpuregs_10_10
* NET  1703 = cpuregs_10_1
* NET  1704 = cpuregs_10_0
* NET  1705 = cpuregs_0_9
* NET  1706 = cpuregs_0_8
* NET  1707 = cpuregs_0_7
* NET  1708 = cpuregs_0_6
* NET  1709 = cpuregs_0_5
* NET  1710 = cpuregs_0_4
* NET  1711 = cpuregs_0_31
* NET  1712 = cpuregs_0_30
* NET  1713 = cpuregs_0_3
* NET  1714 = cpuregs_0_29
* NET  1715 = cpuregs_0_28
* NET  1716 = cpuregs_0_27
* NET  1717 = cpuregs_0_26
* NET  1718 = cpuregs_0_25
* NET  1719 = cpuregs_0_24
* NET  1720 = cpuregs_0_23
* NET  1721 = cpuregs_0_22
* NET  1722 = cpuregs_0_21
* NET  1723 = cpuregs_0_20
* NET  1724 = cpuregs_0_2
* NET  1725 = cpuregs_0_19
* NET  1726 = cpuregs_0_18
* NET  1727 = cpuregs_0_17
* NET  1728 = cpuregs_0_16
* NET  1729 = cpuregs_0_15
* NET  1730 = cpuregs_0_14
* NET  1731 = cpuregs_0_13
* NET  1732 = cpuregs_0_12
* NET  1733 = cpuregs_0_11
* NET  1734 = cpuregs_0_10
* NET  1735 = cpuregs_0_1
* NET  1736 = cpuregs_0_0
* NET  1737 = cpu_state[6]
* NET  1738 = cpu_state[5]
* NET  1739 = cpu_state[4]
* NET  1740 = cpu_state[3]
* NET  1741 = cpu_state[2]
* NET  1742 = cpu_state[1]
* NET  1743 = cpu_state[0]
* NET  1744 = count_instr[9]
* NET  1745 = count_instr[8]
* NET  1746 = count_instr[7]
* NET  1747 = count_instr[63]
* NET  1748 = count_instr[62]
* NET  1749 = count_instr[61]
* NET  1750 = count_instr[60]
* NET  1751 = count_instr[6]
* NET  1752 = count_instr[59]
* NET  1753 = count_instr[58]
* NET  1754 = count_instr[57]
* NET  1755 = count_instr[56]
* NET  1756 = count_instr[55]
* NET  1757 = count_instr[54]
* NET  1758 = count_instr[53]
* NET  1759 = count_instr[52]
* NET  1760 = count_instr[51]
* NET  1761 = count_instr[50]
* NET  1762 = count_instr[5]
* NET  1763 = count_instr[49]
* NET  1764 = count_instr[48]
* NET  1765 = count_instr[47]
* NET  1766 = count_instr[46]
* NET  1767 = count_instr[45]
* NET  1768 = count_instr[44]
* NET  1769 = count_instr[43]
* NET  1770 = count_instr[42]
* NET  1771 = count_instr[41]
* NET  1772 = count_instr[40]
* NET  1773 = count_instr[4]
* NET  1774 = count_instr[39]
* NET  1775 = count_instr[38]
* NET  1776 = count_instr[37]
* NET  1777 = count_instr[36]
* NET  1778 = count_instr[35]
* NET  1779 = count_instr[34]
* NET  1780 = count_instr[33]
* NET  1781 = count_instr[32]
* NET  1782 = count_instr[31]
* NET  1783 = count_instr[30]
* NET  1784 = count_instr[3]
* NET  1785 = count_instr[29]
* NET  1786 = count_instr[28]
* NET  1787 = count_instr[27]
* NET  1788 = count_instr[26]
* NET  1789 = count_instr[25]
* NET  1790 = count_instr[24]
* NET  1791 = count_instr[23]
* NET  1792 = count_instr[22]
* NET  1793 = count_instr[21]
* NET  1794 = count_instr[20]
* NET  1795 = count_instr[2]
* NET  1796 = count_instr[19]
* NET  1797 = count_instr[18]
* NET  1798 = count_instr[17]
* NET  1799 = count_instr[16]
* NET  1800 = count_instr[15]
* NET  1801 = count_instr[14]
* NET  1802 = count_instr[13]
* NET  1803 = count_instr[12]
* NET  1804 = count_instr[11]
* NET  1805 = count_instr[10]
* NET  1806 = count_instr[1]
* NET  1807 = count_instr[0]
* NET  1808 = count_cycle[9]
* NET  1809 = count_cycle[8]
* NET  1810 = count_cycle[7]
* NET  1811 = count_cycle[63]
* NET  1812 = count_cycle[62]
* NET  1813 = count_cycle[61]
* NET  1814 = count_cycle[60]
* NET  1815 = count_cycle[6]
* NET  1816 = count_cycle[59]
* NET  1817 = count_cycle[58]
* NET  1818 = count_cycle[57]
* NET  1819 = count_cycle[56]
* NET  1820 = count_cycle[55]
* NET  1821 = count_cycle[54]
* NET  1822 = count_cycle[53]
* NET  1823 = count_cycle[52]
* NET  1824 = count_cycle[51]
* NET  1825 = count_cycle[50]
* NET  1826 = count_cycle[5]
* NET  1827 = count_cycle[49]
* NET  1828 = count_cycle[48]
* NET  1829 = count_cycle[47]
* NET  1830 = count_cycle[46]
* NET  1831 = count_cycle[45]
* NET  1832 = count_cycle[44]
* NET  1833 = count_cycle[43]
* NET  1834 = count_cycle[42]
* NET  1835 = count_cycle[41]
* NET  1836 = count_cycle[40]
* NET  1837 = count_cycle[4]
* NET  1838 = count_cycle[39]
* NET  1839 = count_cycle[38]
* NET  1840 = count_cycle[37]
* NET  1841 = count_cycle[36]
* NET  1842 = count_cycle[35]
* NET  1843 = count_cycle[34]
* NET  1844 = count_cycle[33]
* NET  1845 = count_cycle[32]
* NET  1846 = count_cycle[31]
* NET  1847 = count_cycle[30]
* NET  1848 = count_cycle[3]
* NET  1849 = count_cycle[29]
* NET  1850 = count_cycle[28]
* NET  1851 = count_cycle[27]
* NET  1852 = count_cycle[26]
* NET  1853 = count_cycle[25]
* NET  1854 = count_cycle[24]
* NET  1855 = count_cycle[23]
* NET  1856 = count_cycle[22]
* NET  1857 = count_cycle[21]
* NET  1858 = count_cycle[20]
* NET  1859 = count_cycle[2]
* NET  1860 = count_cycle[19]
* NET  1861 = count_cycle[18]
* NET  1862 = count_cycle[17]
* NET  1863 = count_cycle[16]
* NET  1864 = count_cycle[15]
* NET  1865 = count_cycle[14]
* NET  1866 = count_cycle[13]
* NET  1867 = count_cycle[12]
* NET  1868 = count_cycle[11]
* NET  1869 = count_cycle[10]
* NET  1870 = count_cycle[1]
* NET  1871 = count_cycle[0]
* NET  1872 = clk
* NET  1873 = alu_out_q[9]
* NET  1874 = alu_out_q[8]
* NET  1875 = alu_out_q[7]
* NET  1876 = alu_out_q[6]
* NET  1877 = alu_out_q[5]
* NET  1878 = alu_out_q[4]
* NET  1879 = alu_out_q[31]
* NET  1880 = alu_out_q[30]
* NET  1881 = alu_out_q[3]
* NET  1882 = alu_out_q[29]
* NET  1883 = alu_out_q[28]
* NET  1884 = alu_out_q[27]
* NET  1885 = alu_out_q[26]
* NET  1886 = alu_out_q[25]
* NET  1887 = alu_out_q[24]
* NET  1888 = alu_out_q[23]
* NET  1889 = alu_out_q[22]
* NET  1890 = alu_out_q[21]
* NET  1891 = alu_out_q[20]
* NET  1892 = alu_out_q[2]
* NET  1893 = alu_out_q[19]
* NET  1894 = alu_out_q[18]
* NET  1895 = alu_out_q[17]
* NET  1896 = alu_out_q[16]
* NET  1897 = alu_out_q[15]
* NET  1898 = alu_out_q[14]
* NET  1899 = alu_out_q[13]
* NET  1900 = alu_out_q[12]
* NET  1901 = alu_out_q[11]
* NET  1902 = alu_out_q[10]
* NET  1903 = alu_out_q[1]
* NET  1904 = alu_out_q[0]
* NET  1905 = alu_out[9]
* NET  1906 = alu_out[8]
* NET  1907 = alu_out[7]
* NET  1908 = alu_out[6]
* NET  1909 = alu_out[5]
* NET  1910 = alu_out[4]
* NET  1911 = alu_out[31]
* NET  1912 = alu_out[30]
* NET  1913 = alu_out[3]
* NET  1914 = alu_out[29]
* NET  1915 = alu_out[28]
* NET  1916 = alu_out[27]
* NET  1917 = alu_out[26]
* NET  1918 = alu_out[25]
* NET  1919 = alu_out[24]
* NET  1920 = alu_out[23]
* NET  1921 = alu_out[22]
* NET  1922 = alu_out[21]
* NET  1923 = alu_out[20]
* NET  1924 = alu_out[2]
* NET  1925 = alu_out[19]
* NET  1926 = alu_out[18]
* NET  1927 = alu_out[17]
* NET  1928 = alu_out[16]
* NET  1929 = alu_out[15]
* NET  1930 = alu_out[14]
* NET  1931 = alu_out[13]
* NET  1932 = alu_out[12]
* NET  1933 = alu_out[11]
* NET  1934 = alu_out[10]
* NET  1935 = alu_out[1]
* NET  1936 = alu_out[0]
* NET  1937 = abc_29733_new_n9999
* NET  1938 = abc_29733_new_n9998
* NET  1939 = abc_29733_new_n9997
* NET  1940 = abc_29733_new_n9996
* NET  1941 = abc_29733_new_n9995
* NET  1942 = abc_29733_new_n9994
* NET  1943 = abc_29733_new_n9993
* NET  1944 = abc_29733_new_n9992
* NET  1945 = abc_29733_new_n9990
* NET  1946 = abc_29733_new_n9989
* NET  1947 = abc_29733_new_n9988
* NET  1948 = abc_29733_new_n9987
* NET  1949 = abc_29733_new_n9986
* NET  1950 = abc_29733_new_n9985
* NET  1951 = abc_29733_new_n9984
* NET  1952 = abc_29733_new_n9983
* NET  1953 = abc_29733_new_n9982
* NET  1954 = abc_29733_new_n9981
* NET  1955 = abc_29733_new_n9980
* NET  1956 = abc_29733_new_n9979
* NET  1957 = abc_29733_new_n9978
* NET  1958 = abc_29733_new_n9977
* NET  1959 = abc_29733_new_n9976
* NET  1960 = abc_29733_new_n9975
* NET  1961 = abc_29733_new_n9974
* NET  1962 = abc_29733_new_n9973
* NET  1963 = abc_29733_new_n9972
* NET  1964 = abc_29733_new_n9971
* NET  1965 = abc_29733_new_n9970
* NET  1966 = abc_29733_new_n9969
* NET  1967 = abc_29733_new_n9968
* NET  1968 = abc_29733_new_n9967
* NET  1969 = abc_29733_new_n9966
* NET  1970 = abc_29733_new_n9965
* NET  1971 = abc_29733_new_n9964
* NET  1972 = abc_29733_new_n9963
* NET  1973 = abc_29733_new_n9962
* NET  1974 = abc_29733_new_n9961
* NET  1975 = abc_29733_new_n9960
* NET  1976 = abc_29733_new_n9959
* NET  1977 = abc_29733_new_n9958
* NET  1978 = abc_29733_new_n9957
* NET  1979 = abc_29733_new_n9956
* NET  1980 = abc_29733_new_n9955
* NET  1981 = abc_29733_new_n9954
* NET  1982 = abc_29733_new_n9953
* NET  1983 = abc_29733_new_n9952
* NET  1984 = abc_29733_new_n9951
* NET  1985 = abc_29733_new_n9950
* NET  1986 = abc_29733_new_n9949
* NET  1987 = abc_29733_new_n9948
* NET  1988 = abc_29733_new_n9946
* NET  1989 = abc_29733_new_n9945
* NET  1990 = abc_29733_new_n9944
* NET  1991 = abc_29733_new_n9943
* NET  1992 = abc_29733_new_n9942
* NET  1993 = abc_29733_new_n9941
* NET  1994 = abc_29733_new_n9940
* NET  1995 = abc_29733_new_n9939
* NET  1996 = abc_29733_new_n9938
* NET  1997 = abc_29733_new_n9937
* NET  1998 = abc_29733_new_n9936
* NET  1999 = abc_29733_new_n9935
* NET  2000 = abc_29733_new_n9934
* NET  2001 = abc_29733_new_n9933
* NET  2002 = abc_29733_new_n9932
* NET  2003 = abc_29733_new_n9931
* NET  2004 = abc_29733_new_n9930
* NET  2005 = abc_29733_new_n9929
* NET  2006 = abc_29733_new_n9928
* NET  2007 = abc_29733_new_n9927
* NET  2008 = abc_29733_new_n9926
* NET  2009 = abc_29733_new_n9925
* NET  2010 = abc_29733_new_n9924
* NET  2011 = abc_29733_new_n9923
* NET  2012 = abc_29733_new_n9922
* NET  2013 = abc_29733_new_n9921
* NET  2014 = abc_29733_new_n9920
* NET  2015 = abc_29733_new_n9919
* NET  2016 = abc_29733_new_n9918
* NET  2017 = abc_29733_new_n9917
* NET  2018 = abc_29733_new_n9916
* NET  2019 = abc_29733_new_n9915
* NET  2020 = abc_29733_new_n9914
* NET  2021 = abc_29733_new_n9913
* NET  2022 = abc_29733_new_n9912
* NET  2023 = abc_29733_new_n9911
* NET  2024 = abc_29733_new_n9910
* NET  2025 = abc_29733_new_n9909
* NET  2026 = abc_29733_new_n9908
* NET  2027 = abc_29733_new_n9907
* NET  2028 = abc_29733_new_n9906
* NET  2029 = abc_29733_new_n9905
* NET  2030 = abc_29733_new_n9904
* NET  2031 = abc_29733_new_n9903
* NET  2032 = abc_29733_new_n9902
* NET  2033 = abc_29733_new_n9901
* NET  2034 = abc_29733_new_n9900
* NET  2035 = abc_29733_new_n9898
* NET  2036 = abc_29733_new_n9897
* NET  2037 = abc_29733_new_n9896
* NET  2038 = abc_29733_new_n9895
* NET  2039 = abc_29733_new_n9894
* NET  2040 = abc_29733_new_n9893
* NET  2041 = abc_29733_new_n9892
* NET  2042 = abc_29733_new_n9891
* NET  2043 = abc_29733_new_n9890
* NET  2044 = abc_29733_new_n9889
* NET  2045 = abc_29733_new_n9888
* NET  2046 = abc_29733_new_n9887
* NET  2047 = abc_29733_new_n9886
* NET  2048 = abc_29733_new_n9885
* NET  2049 = abc_29733_new_n9884
* NET  2050 = abc_29733_new_n9883
* NET  2051 = abc_29733_new_n9882
* NET  2052 = abc_29733_new_n9881
* NET  2053 = abc_29733_new_n9880
* NET  2054 = abc_29733_new_n9879
* NET  2055 = abc_29733_new_n9878
* NET  2056 = abc_29733_new_n9877
* NET  2057 = abc_29733_new_n9876
* NET  2058 = abc_29733_new_n9875
* NET  2059 = abc_29733_new_n9874
* NET  2060 = abc_29733_new_n9873
* NET  2061 = abc_29733_new_n9872
* NET  2062 = abc_29733_new_n9871
* NET  2063 = abc_29733_new_n9870
* NET  2064 = abc_29733_new_n9869
* NET  2065 = abc_29733_new_n9868
* NET  2066 = abc_29733_new_n9867
* NET  2067 = abc_29733_new_n9866
* NET  2068 = abc_29733_new_n9865
* NET  2069 = abc_29733_new_n9864
* NET  2070 = abc_29733_new_n9863
* NET  2071 = abc_29733_new_n9862
* NET  2072 = abc_29733_new_n9861
* NET  2073 = abc_29733_new_n9860
* NET  2074 = abc_29733_new_n9859
* NET  2075 = abc_29733_new_n9858
* NET  2076 = abc_29733_new_n9856
* NET  2077 = abc_29733_new_n9855
* NET  2078 = abc_29733_new_n9854
* NET  2079 = abc_29733_new_n9853
* NET  2080 = abc_29733_new_n9852
* NET  2081 = abc_29733_new_n9851
* NET  2082 = abc_29733_new_n9850
* NET  2083 = abc_29733_new_n9849
* NET  2084 = abc_29733_new_n9848
* NET  2085 = abc_29733_new_n9847
* NET  2086 = abc_29733_new_n9846
* NET  2087 = abc_29733_new_n9845
* NET  2088 = abc_29733_new_n9844
* NET  2089 = abc_29733_new_n9843
* NET  2090 = abc_29733_new_n9842
* NET  2091 = abc_29733_new_n9841
* NET  2092 = abc_29733_new_n9840
* NET  2093 = abc_29733_new_n9839
* NET  2094 = abc_29733_new_n9838
* NET  2095 = abc_29733_new_n9837
* NET  2096 = abc_29733_new_n9836
* NET  2097 = abc_29733_new_n9835
* NET  2098 = abc_29733_new_n9834
* NET  2099 = abc_29733_new_n9833
* NET  2100 = abc_29733_new_n9832
* NET  2101 = abc_29733_new_n9831
* NET  2102 = abc_29733_new_n9830
* NET  2103 = abc_29733_new_n9829
* NET  2104 = abc_29733_new_n9828
* NET  2105 = abc_29733_new_n9827
* NET  2106 = abc_29733_new_n9826
* NET  2107 = abc_29733_new_n9825
* NET  2108 = abc_29733_new_n9824
* NET  2109 = abc_29733_new_n9823
* NET  2110 = abc_29733_new_n9822
* NET  2111 = abc_29733_new_n9821
* NET  2112 = abc_29733_new_n9820
* NET  2113 = abc_29733_new_n9819
* NET  2114 = abc_29733_new_n9818
* NET  2115 = abc_29733_new_n9817
* NET  2116 = abc_29733_new_n9816
* NET  2117 = abc_29733_new_n9815
* NET  2118 = abc_29733_new_n9814
* NET  2119 = abc_29733_new_n9813
* NET  2120 = abc_29733_new_n9812
* NET  2121 = abc_29733_new_n9811
* NET  2122 = abc_29733_new_n9810
* NET  2123 = abc_29733_new_n9809
* NET  2124 = abc_29733_new_n9808
* NET  2125 = abc_29733_new_n9807
* NET  2126 = abc_29733_new_n9806
* NET  2127 = abc_29733_new_n9804
* NET  2128 = abc_29733_new_n9803
* NET  2129 = abc_29733_new_n9802
* NET  2130 = abc_29733_new_n9801
* NET  2131 = abc_29733_new_n9800
* NET  2132 = abc_29733_new_n9799
* NET  2133 = abc_29733_new_n9798
* NET  2134 = abc_29733_new_n9797
* NET  2135 = abc_29733_new_n9796
* NET  2136 = abc_29733_new_n9795
* NET  2137 = abc_29733_new_n9794
* NET  2138 = abc_29733_new_n9793
* NET  2139 = abc_29733_new_n9792
* NET  2140 = abc_29733_new_n9791
* NET  2141 = abc_29733_new_n9790
* NET  2142 = abc_29733_new_n9789
* NET  2143 = abc_29733_new_n9788
* NET  2144 = abc_29733_new_n9787
* NET  2145 = abc_29733_new_n9786
* NET  2146 = abc_29733_new_n9785
* NET  2147 = abc_29733_new_n9784
* NET  2148 = abc_29733_new_n9783
* NET  2149 = abc_29733_new_n9782
* NET  2150 = abc_29733_new_n9781
* NET  2151 = abc_29733_new_n9780
* NET  2152 = abc_29733_new_n9779
* NET  2153 = abc_29733_new_n9778
* NET  2154 = abc_29733_new_n9777
* NET  2155 = abc_29733_new_n9776
* NET  2156 = abc_29733_new_n9775
* NET  2157 = abc_29733_new_n9774
* NET  2158 = abc_29733_new_n9773
* NET  2159 = abc_29733_new_n9772
* NET  2160 = abc_29733_new_n9771
* NET  2161 = abc_29733_new_n9770
* NET  2162 = abc_29733_new_n9769
* NET  2163 = abc_29733_new_n9768
* NET  2164 = abc_29733_new_n9767
* NET  2165 = abc_29733_new_n9766
* NET  2166 = abc_29733_new_n9765
* NET  2167 = abc_29733_new_n9764
* NET  2168 = abc_29733_new_n9763
* NET  2169 = abc_29733_new_n9762
* NET  2170 = abc_29733_new_n9761
* NET  2171 = abc_29733_new_n9760
* NET  2172 = abc_29733_new_n9759
* NET  2173 = abc_29733_new_n9758
* NET  2174 = abc_29733_new_n9756
* NET  2175 = abc_29733_new_n9755
* NET  2176 = abc_29733_new_n9754
* NET  2177 = abc_29733_new_n9753
* NET  2178 = abc_29733_new_n9752
* NET  2179 = abc_29733_new_n9751
* NET  2180 = abc_29733_new_n9750
* NET  2181 = abc_29733_new_n9749
* NET  2182 = abc_29733_new_n9748
* NET  2183 = abc_29733_new_n9747
* NET  2184 = abc_29733_new_n9746
* NET  2185 = abc_29733_new_n9745
* NET  2186 = abc_29733_new_n9744
* NET  2187 = abc_29733_new_n9743
* NET  2188 = abc_29733_new_n9742
* NET  2189 = abc_29733_new_n9741
* NET  2190 = abc_29733_new_n9740
* NET  2191 = abc_29733_new_n9739
* NET  2192 = abc_29733_new_n9738
* NET  2193 = abc_29733_new_n9737
* NET  2194 = abc_29733_new_n9736
* NET  2195 = abc_29733_new_n9735
* NET  2196 = abc_29733_new_n9734
* NET  2197 = abc_29733_new_n9733
* NET  2198 = abc_29733_new_n9732
* NET  2199 = abc_29733_new_n9731
* NET  2200 = abc_29733_new_n9730
* NET  2201 = abc_29733_new_n9729
* NET  2202 = abc_29733_new_n9728
* NET  2203 = abc_29733_new_n9727
* NET  2204 = abc_29733_new_n9726
* NET  2205 = abc_29733_new_n9725
* NET  2206 = abc_29733_new_n9724
* NET  2207 = abc_29733_new_n9723
* NET  2208 = abc_29733_new_n9722
* NET  2209 = abc_29733_new_n9721
* NET  2210 = abc_29733_new_n9720
* NET  2211 = abc_29733_new_n9719
* NET  2212 = abc_29733_new_n9718
* NET  2213 = abc_29733_new_n9717
* NET  2214 = abc_29733_new_n9715
* NET  2215 = abc_29733_new_n9714
* NET  2216 = abc_29733_new_n9713
* NET  2217 = abc_29733_new_n9712
* NET  2218 = abc_29733_new_n9711
* NET  2219 = abc_29733_new_n9710
* NET  2220 = abc_29733_new_n9709
* NET  2221 = abc_29733_new_n9708
* NET  2222 = abc_29733_new_n9707
* NET  2223 = abc_29733_new_n9706
* NET  2224 = abc_29733_new_n9705
* NET  2225 = abc_29733_new_n9704
* NET  2226 = abc_29733_new_n9703
* NET  2227 = abc_29733_new_n9702
* NET  2228 = abc_29733_new_n9701
* NET  2229 = abc_29733_new_n9700
* NET  2230 = abc_29733_new_n9699
* NET  2231 = abc_29733_new_n9698
* NET  2232 = abc_29733_new_n9697
* NET  2233 = abc_29733_new_n9696
* NET  2234 = abc_29733_new_n9695
* NET  2235 = abc_29733_new_n9694
* NET  2236 = abc_29733_new_n9693
* NET  2237 = abc_29733_new_n9692
* NET  2238 = abc_29733_new_n9691
* NET  2239 = abc_29733_new_n9690
* NET  2240 = abc_29733_new_n9689
* NET  2241 = abc_29733_new_n9688
* NET  2242 = abc_29733_new_n9687
* NET  2243 = abc_29733_new_n9686
* NET  2244 = abc_29733_new_n9685
* NET  2245 = abc_29733_new_n9684
* NET  2246 = abc_29733_new_n9683
* NET  2247 = abc_29733_new_n9682
* NET  2248 = abc_29733_new_n9681
* NET  2249 = abc_29733_new_n9680
* NET  2250 = abc_29733_new_n9679
* NET  2251 = abc_29733_new_n9678
* NET  2252 = abc_29733_new_n9677
* NET  2253 = abc_29733_new_n9676
* NET  2254 = abc_29733_new_n9675
* NET  2255 = abc_29733_new_n9674
* NET  2256 = abc_29733_new_n9673
* NET  2257 = abc_29733_new_n9671
* NET  2258 = abc_29733_new_n9670
* NET  2259 = abc_29733_new_n9669
* NET  2260 = abc_29733_new_n9668
* NET  2261 = abc_29733_new_n9667
* NET  2262 = abc_29733_new_n9666
* NET  2263 = abc_29733_new_n9665
* NET  2264 = abc_29733_new_n9664
* NET  2265 = abc_29733_new_n9663
* NET  2266 = abc_29733_new_n9662
* NET  2267 = abc_29733_new_n9661
* NET  2268 = abc_29733_new_n9660
* NET  2269 = abc_29733_new_n9659
* NET  2270 = abc_29733_new_n9658
* NET  2271 = abc_29733_new_n9657
* NET  2272 = abc_29733_new_n9656
* NET  2273 = abc_29733_new_n9655
* NET  2274 = abc_29733_new_n9654
* NET  2275 = abc_29733_new_n9653
* NET  2276 = abc_29733_new_n9652
* NET  2277 = abc_29733_new_n9651
* NET  2278 = abc_29733_new_n9650
* NET  2279 = abc_29733_new_n9649
* NET  2280 = abc_29733_new_n9648
* NET  2281 = abc_29733_new_n9647
* NET  2282 = abc_29733_new_n9646
* NET  2283 = abc_29733_new_n9645
* NET  2284 = abc_29733_new_n9644
* NET  2285 = abc_29733_new_n9643
* NET  2286 = abc_29733_new_n9642
* NET  2287 = abc_29733_new_n9641
* NET  2288 = abc_29733_new_n9640
* NET  2289 = abc_29733_new_n9639
* NET  2290 = abc_29733_new_n9638
* NET  2291 = abc_29733_new_n9637
* NET  2292 = abc_29733_new_n9636
* NET  2293 = abc_29733_new_n9635
* NET  2294 = abc_29733_new_n9634
* NET  2295 = abc_29733_new_n9633
* NET  2296 = abc_29733_new_n9632
* NET  2297 = abc_29733_new_n9631
* NET  2298 = abc_29733_new_n9630
* NET  2299 = abc_29733_new_n9629
* NET  2300 = abc_29733_new_n9628
* NET  2301 = abc_29733_new_n9627
* NET  2302 = abc_29733_new_n9626
* NET  2303 = abc_29733_new_n9625
* NET  2304 = abc_29733_new_n9623
* NET  2305 = abc_29733_new_n9622
* NET  2306 = abc_29733_new_n9621
* NET  2307 = abc_29733_new_n9620
* NET  2308 = abc_29733_new_n9619
* NET  2309 = abc_29733_new_n9618
* NET  2310 = abc_29733_new_n9617
* NET  2311 = abc_29733_new_n9616
* NET  2312 = abc_29733_new_n9615
* NET  2313 = abc_29733_new_n9614
* NET  2314 = abc_29733_new_n9613
* NET  2315 = abc_29733_new_n9612
* NET  2316 = abc_29733_new_n9611
* NET  2317 = abc_29733_new_n9610
* NET  2318 = abc_29733_new_n9609
* NET  2319 = abc_29733_new_n9608
* NET  2320 = abc_29733_new_n9607
* NET  2321 = abc_29733_new_n9606
* NET  2322 = abc_29733_new_n9605
* NET  2323 = abc_29733_new_n9604
* NET  2324 = abc_29733_new_n9603
* NET  2325 = abc_29733_new_n9602
* NET  2326 = abc_29733_new_n9601
* NET  2327 = abc_29733_new_n9600
* NET  2328 = abc_29733_new_n9599
* NET  2329 = abc_29733_new_n9598
* NET  2330 = abc_29733_new_n9597
* NET  2331 = abc_29733_new_n9596
* NET  2332 = abc_29733_new_n9595
* NET  2333 = abc_29733_new_n9594
* NET  2334 = abc_29733_new_n9593
* NET  2335 = abc_29733_new_n9592
* NET  2336 = abc_29733_new_n9591
* NET  2337 = abc_29733_new_n9590
* NET  2338 = abc_29733_new_n9589
* NET  2339 = abc_29733_new_n9588
* NET  2340 = abc_29733_new_n9587
* NET  2341 = abc_29733_new_n9586
* NET  2342 = abc_29733_new_n9585
* NET  2343 = abc_29733_new_n9584
* NET  2344 = abc_29733_new_n9583
* NET  2345 = abc_29733_new_n9582
* NET  2346 = abc_29733_new_n9581
* NET  2347 = abc_29733_new_n9579
* NET  2348 = abc_29733_new_n9578
* NET  2349 = abc_29733_new_n9577
* NET  2350 = abc_29733_new_n9576
* NET  2351 = abc_29733_new_n9575
* NET  2352 = abc_29733_new_n9574
* NET  2353 = abc_29733_new_n9573
* NET  2354 = abc_29733_new_n9572
* NET  2355 = abc_29733_new_n9571
* NET  2356 = abc_29733_new_n9570
* NET  2357 = abc_29733_new_n9569
* NET  2358 = abc_29733_new_n9568
* NET  2359 = abc_29733_new_n9567
* NET  2360 = abc_29733_new_n9566
* NET  2361 = abc_29733_new_n9565
* NET  2362 = abc_29733_new_n9564
* NET  2363 = abc_29733_new_n9563
* NET  2364 = abc_29733_new_n9562
* NET  2365 = abc_29733_new_n9561
* NET  2366 = abc_29733_new_n9560
* NET  2367 = abc_29733_new_n9559
* NET  2368 = abc_29733_new_n9558
* NET  2369 = abc_29733_new_n9557
* NET  2370 = abc_29733_new_n9556
* NET  2371 = abc_29733_new_n9555
* NET  2372 = abc_29733_new_n9554
* NET  2373 = abc_29733_new_n9553
* NET  2374 = abc_29733_new_n9552
* NET  2375 = abc_29733_new_n9551
* NET  2376 = abc_29733_new_n9550
* NET  2377 = abc_29733_new_n9549
* NET  2378 = abc_29733_new_n9548
* NET  2379 = abc_29733_new_n9547
* NET  2380 = abc_29733_new_n9546
* NET  2381 = abc_29733_new_n9545
* NET  2382 = abc_29733_new_n9544
* NET  2383 = abc_29733_new_n9543
* NET  2384 = abc_29733_new_n9542
* NET  2385 = abc_29733_new_n9541
* NET  2386 = abc_29733_new_n9540
* NET  2387 = abc_29733_new_n9539
* NET  2388 = abc_29733_new_n9538
* NET  2389 = abc_29733_new_n9537
* NET  2390 = abc_29733_new_n9535
* NET  2391 = abc_29733_new_n9534
* NET  2392 = abc_29733_new_n9533
* NET  2393 = abc_29733_new_n9532
* NET  2394 = abc_29733_new_n9531
* NET  2395 = abc_29733_new_n9530
* NET  2396 = abc_29733_new_n9529
* NET  2397 = abc_29733_new_n9528
* NET  2398 = abc_29733_new_n9527
* NET  2399 = abc_29733_new_n9526
* NET  2400 = abc_29733_new_n9525
* NET  2401 = abc_29733_new_n9524
* NET  2402 = abc_29733_new_n9523
* NET  2403 = abc_29733_new_n9522
* NET  2404 = abc_29733_new_n9521
* NET  2405 = abc_29733_new_n9520
* NET  2406 = abc_29733_new_n9519
* NET  2407 = abc_29733_new_n9518
* NET  2408 = abc_29733_new_n9517
* NET  2409 = abc_29733_new_n9516
* NET  2410 = abc_29733_new_n9515
* NET  2411 = abc_29733_new_n9514
* NET  2412 = abc_29733_new_n9513
* NET  2413 = abc_29733_new_n9512
* NET  2414 = abc_29733_new_n9511
* NET  2415 = abc_29733_new_n9510
* NET  2416 = abc_29733_new_n9509
* NET  2417 = abc_29733_new_n9508
* NET  2418 = abc_29733_new_n9507
* NET  2419 = abc_29733_new_n9506
* NET  2420 = abc_29733_new_n9505
* NET  2421 = abc_29733_new_n9504
* NET  2422 = abc_29733_new_n9503
* NET  2423 = abc_29733_new_n9502
* NET  2424 = abc_29733_new_n9501
* NET  2425 = abc_29733_new_n9500
* NET  2426 = abc_29733_new_n9499
* NET  2427 = abc_29733_new_n9498
* NET  2428 = abc_29733_new_n9497
* NET  2429 = abc_29733_new_n9496
* NET  2430 = abc_29733_new_n9495
* NET  2431 = abc_29733_new_n9493
* NET  2432 = abc_29733_new_n9492
* NET  2433 = abc_29733_new_n9491
* NET  2434 = abc_29733_new_n9490
* NET  2435 = abc_29733_new_n9489
* NET  2436 = abc_29733_new_n9488
* NET  2437 = abc_29733_new_n9487
* NET  2438 = abc_29733_new_n9486
* NET  2439 = abc_29733_new_n9485
* NET  2440 = abc_29733_new_n9484
* NET  2441 = abc_29733_new_n9483
* NET  2442 = abc_29733_new_n9482
* NET  2443 = abc_29733_new_n9481
* NET  2444 = abc_29733_new_n9480
* NET  2445 = abc_29733_new_n9479
* NET  2446 = abc_29733_new_n9478
* NET  2447 = abc_29733_new_n9477
* NET  2448 = abc_29733_new_n9476
* NET  2449 = abc_29733_new_n9475
* NET  2450 = abc_29733_new_n9474
* NET  2451 = abc_29733_new_n9473
* NET  2452 = abc_29733_new_n9472
* NET  2453 = abc_29733_new_n9471
* NET  2454 = abc_29733_new_n9470
* NET  2455 = abc_29733_new_n9469
* NET  2456 = abc_29733_new_n9468
* NET  2457 = abc_29733_new_n9467
* NET  2458 = abc_29733_new_n9466
* NET  2459 = abc_29733_new_n9465
* NET  2460 = abc_29733_new_n9464
* NET  2461 = abc_29733_new_n9463
* NET  2462 = abc_29733_new_n9462
* NET  2463 = abc_29733_new_n9461
* NET  2464 = abc_29733_new_n9460
* NET  2465 = abc_29733_new_n9459
* NET  2466 = abc_29733_new_n9458
* NET  2467 = abc_29733_new_n9457
* NET  2468 = abc_29733_new_n9456
* NET  2469 = abc_29733_new_n9455
* NET  2470 = abc_29733_new_n9454
* NET  2471 = abc_29733_new_n9453
* NET  2472 = abc_29733_new_n9452
* NET  2473 = abc_29733_new_n9451
* NET  2474 = abc_29733_new_n9450
* NET  2475 = abc_29733_new_n9449
* NET  2476 = abc_29733_new_n9448
* NET  2477 = abc_29733_new_n9447
* NET  2478 = abc_29733_new_n9446
* NET  2479 = abc_29733_new_n9445
* NET  2480 = abc_29733_new_n9444
* NET  2481 = abc_29733_new_n9443
* NET  2482 = abc_29733_new_n9441
* NET  2483 = abc_29733_new_n9440
* NET  2484 = abc_29733_new_n9439
* NET  2485 = abc_29733_new_n9438
* NET  2486 = abc_29733_new_n9437
* NET  2487 = abc_29733_new_n9436
* NET  2488 = abc_29733_new_n9435
* NET  2489 = abc_29733_new_n9434
* NET  2490 = abc_29733_new_n9433
* NET  2491 = abc_29733_new_n9432
* NET  2492 = abc_29733_new_n9431
* NET  2493 = abc_29733_new_n9430
* NET  2494 = abc_29733_new_n9429
* NET  2495 = abc_29733_new_n9428
* NET  2496 = abc_29733_new_n9427
* NET  2497 = abc_29733_new_n9426
* NET  2498 = abc_29733_new_n9425
* NET  2499 = abc_29733_new_n9424
* NET  2500 = abc_29733_new_n9423
* NET  2501 = abc_29733_new_n9422
* NET  2502 = abc_29733_new_n9421
* NET  2503 = abc_29733_new_n9420
* NET  2504 = abc_29733_new_n9419
* NET  2505 = abc_29733_new_n9418
* NET  2506 = abc_29733_new_n9417
* NET  2507 = abc_29733_new_n9416
* NET  2508 = abc_29733_new_n9415
* NET  2509 = abc_29733_new_n9414
* NET  2510 = abc_29733_new_n9413
* NET  2511 = abc_29733_new_n9412
* NET  2512 = abc_29733_new_n9411
* NET  2513 = abc_29733_new_n9410
* NET  2514 = abc_29733_new_n9409
* NET  2515 = abc_29733_new_n9408
* NET  2516 = abc_29733_new_n9406
* NET  2517 = abc_29733_new_n9405
* NET  2518 = abc_29733_new_n9404
* NET  2519 = abc_29733_new_n9403
* NET  2520 = abc_29733_new_n9402
* NET  2521 = abc_29733_new_n9401
* NET  2522 = abc_29733_new_n9400
* NET  2523 = abc_29733_new_n9399
* NET  2524 = abc_29733_new_n9398
* NET  2525 = abc_29733_new_n9397
* NET  2526 = abc_29733_new_n9396
* NET  2527 = abc_29733_new_n9395
* NET  2528 = abc_29733_new_n9394
* NET  2529 = abc_29733_new_n9393
* NET  2530 = abc_29733_new_n9392
* NET  2531 = abc_29733_new_n9391
* NET  2532 = abc_29733_new_n9390
* NET  2533 = abc_29733_new_n9389
* NET  2534 = abc_29733_new_n9388
* NET  2535 = abc_29733_new_n9387
* NET  2536 = abc_29733_new_n9386
* NET  2537 = abc_29733_new_n9385
* NET  2538 = abc_29733_new_n9384
* NET  2539 = abc_29733_new_n9383
* NET  2540 = abc_29733_new_n9382
* NET  2541 = abc_29733_new_n9381
* NET  2542 = abc_29733_new_n9380
* NET  2543 = abc_29733_new_n9379
* NET  2544 = abc_29733_new_n9378
* NET  2545 = abc_29733_new_n9377
* NET  2546 = abc_29733_new_n9376
* NET  2547 = abc_29733_new_n9375
* NET  2548 = abc_29733_new_n9374
* NET  2549 = abc_29733_new_n9373
* NET  2550 = abc_29733_new_n9372
* NET  2551 = abc_29733_new_n9371
* NET  2552 = abc_29733_new_n9370
* NET  2553 = abc_29733_new_n9369
* NET  2554 = abc_29733_new_n9368
* NET  2555 = abc_29733_new_n9367
* NET  2556 = abc_29733_new_n9366
* NET  2557 = abc_29733_new_n9365
* NET  2558 = abc_29733_new_n9364
* NET  2559 = abc_29733_new_n9363
* NET  2560 = abc_29733_new_n9362
* NET  2561 = abc_29733_new_n9361
* NET  2562 = abc_29733_new_n9360
* NET  2563 = abc_29733_new_n9359
* NET  2564 = abc_29733_new_n9358
* NET  2565 = abc_29733_new_n9357
* NET  2566 = abc_29733_new_n9356
* NET  2567 = abc_29733_new_n9354
* NET  2568 = abc_29733_new_n9353
* NET  2569 = abc_29733_new_n9352
* NET  2570 = abc_29733_new_n9351
* NET  2571 = abc_29733_new_n9350
* NET  2572 = abc_29733_new_n9349
* NET  2573 = abc_29733_new_n9348
* NET  2574 = abc_29733_new_n9347
* NET  2575 = abc_29733_new_n9346
* NET  2576 = abc_29733_new_n9345
* NET  2577 = abc_29733_new_n9344
* NET  2578 = abc_29733_new_n9343
* NET  2579 = abc_29733_new_n9342
* NET  2580 = abc_29733_new_n9341
* NET  2581 = abc_29733_new_n9340
* NET  2582 = abc_29733_new_n9339
* NET  2583 = abc_29733_new_n9338
* NET  2584 = abc_29733_new_n9337
* NET  2585 = abc_29733_new_n9336
* NET  2586 = abc_29733_new_n9335
* NET  2587 = abc_29733_new_n9334
* NET  2588 = abc_29733_new_n9333
* NET  2589 = abc_29733_new_n9332
* NET  2590 = abc_29733_new_n9331
* NET  2591 = abc_29733_new_n9330
* NET  2592 = abc_29733_new_n9329
* NET  2593 = abc_29733_new_n9328
* NET  2594 = abc_29733_new_n9327
* NET  2595 = abc_29733_new_n9326
* NET  2596 = abc_29733_new_n9325
* NET  2597 = abc_29733_new_n9324
* NET  2598 = abc_29733_new_n9323
* NET  2599 = abc_29733_new_n9322
* NET  2600 = abc_29733_new_n9321
* NET  2601 = abc_29733_new_n9320
* NET  2602 = abc_29733_new_n9319
* NET  2603 = abc_29733_new_n9318
* NET  2604 = abc_29733_new_n9317
* NET  2605 = abc_29733_new_n9316
* NET  2606 = abc_29733_new_n9315
* NET  2607 = abc_29733_new_n9314
* NET  2608 = abc_29733_new_n9313
* NET  2609 = abc_29733_new_n9312
* NET  2610 = abc_29733_new_n9310
* NET  2611 = abc_29733_new_n9309
* NET  2612 = abc_29733_new_n9308
* NET  2613 = abc_29733_new_n9307
* NET  2614 = abc_29733_new_n9306
* NET  2615 = abc_29733_new_n9305
* NET  2616 = abc_29733_new_n9304
* NET  2617 = abc_29733_new_n9303
* NET  2618 = abc_29733_new_n9302
* NET  2619 = abc_29733_new_n9301
* NET  2620 = abc_29733_new_n9300
* NET  2621 = abc_29733_new_n9299
* NET  2622 = abc_29733_new_n9298
* NET  2623 = abc_29733_new_n9297
* NET  2624 = abc_29733_new_n9296
* NET  2625 = abc_29733_new_n9295
* NET  2626 = abc_29733_new_n9294
* NET  2627 = abc_29733_new_n9293
* NET  2628 = abc_29733_new_n9292
* NET  2629 = abc_29733_new_n9291
* NET  2630 = abc_29733_new_n9290
* NET  2631 = abc_29733_new_n9289
* NET  2632 = abc_29733_new_n9288
* NET  2633 = abc_29733_new_n9287
* NET  2634 = abc_29733_new_n9286
* NET  2635 = abc_29733_new_n9285
* NET  2636 = abc_29733_new_n9284
* NET  2637 = abc_29733_new_n9283
* NET  2638 = abc_29733_new_n9282
* NET  2639 = abc_29733_new_n9281
* NET  2640 = abc_29733_new_n9280
* NET  2641 = abc_29733_new_n9279
* NET  2642 = abc_29733_new_n9278
* NET  2643 = abc_29733_new_n9277
* NET  2644 = abc_29733_new_n9276
* NET  2645 = abc_29733_new_n9275
* NET  2646 = abc_29733_new_n9274
* NET  2647 = abc_29733_new_n9273
* NET  2648 = abc_29733_new_n9272
* NET  2649 = abc_29733_new_n9271
* NET  2650 = abc_29733_new_n9270
* NET  2651 = abc_29733_new_n9269
* NET  2652 = abc_29733_new_n9268
* NET  2653 = abc_29733_new_n9267
* NET  2654 = abc_29733_new_n9265
* NET  2655 = abc_29733_new_n9264
* NET  2656 = abc_29733_new_n9263
* NET  2657 = abc_29733_new_n9262
* NET  2658 = abc_29733_new_n9261
* NET  2659 = abc_29733_new_n9260
* NET  2660 = abc_29733_new_n9259
* NET  2661 = abc_29733_new_n9258
* NET  2662 = abc_29733_new_n9257
* NET  2663 = abc_29733_new_n9256
* NET  2664 = abc_29733_new_n9255
* NET  2665 = abc_29733_new_n9254
* NET  2666 = abc_29733_new_n9253
* NET  2667 = abc_29733_new_n9252
* NET  2668 = abc_29733_new_n9251
* NET  2669 = abc_29733_new_n9250
* NET  2670 = abc_29733_new_n9249
* NET  2671 = abc_29733_new_n9248
* NET  2672 = abc_29733_new_n9247
* NET  2673 = abc_29733_new_n9246
* NET  2674 = abc_29733_new_n9245
* NET  2675 = abc_29733_new_n9244
* NET  2676 = abc_29733_new_n9243
* NET  2677 = abc_29733_new_n9242
* NET  2678 = abc_29733_new_n9241
* NET  2679 = abc_29733_new_n9240
* NET  2680 = abc_29733_new_n9239
* NET  2681 = abc_29733_new_n9238
* NET  2682 = abc_29733_new_n9237
* NET  2683 = abc_29733_new_n9236
* NET  2684 = abc_29733_new_n9235
* NET  2685 = abc_29733_new_n9234
* NET  2686 = abc_29733_new_n9233
* NET  2687 = abc_29733_new_n9232
* NET  2688 = abc_29733_new_n9231
* NET  2689 = abc_29733_new_n9230
* NET  2690 = abc_29733_new_n9229
* NET  2691 = abc_29733_new_n9228
* NET  2692 = abc_29733_new_n9227
* NET  2693 = abc_29733_new_n9226
* NET  2694 = abc_29733_new_n9225
* NET  2695 = abc_29733_new_n9223
* NET  2696 = abc_29733_new_n9222
* NET  2697 = abc_29733_new_n9221
* NET  2698 = abc_29733_new_n9220
* NET  2699 = abc_29733_new_n9219
* NET  2700 = abc_29733_new_n9218
* NET  2701 = abc_29733_new_n9217
* NET  2702 = abc_29733_new_n9216
* NET  2703 = abc_29733_new_n9215
* NET  2704 = abc_29733_new_n9214
* NET  2705 = abc_29733_new_n9213
* NET  2706 = abc_29733_new_n9212
* NET  2707 = abc_29733_new_n9211
* NET  2708 = abc_29733_new_n9210
* NET  2709 = abc_29733_new_n9209
* NET  2710 = abc_29733_new_n9208
* NET  2711 = abc_29733_new_n9207
* NET  2712 = abc_29733_new_n9206
* NET  2713 = abc_29733_new_n9205
* NET  2714 = abc_29733_new_n9204
* NET  2715 = abc_29733_new_n9203
* NET  2716 = abc_29733_new_n9202
* NET  2717 = abc_29733_new_n9201
* NET  2718 = abc_29733_new_n9200
* NET  2719 = abc_29733_new_n9199
* NET  2720 = abc_29733_new_n9198
* NET  2721 = abc_29733_new_n9197
* NET  2722 = abc_29733_new_n9196
* NET  2723 = abc_29733_new_n9195
* NET  2724 = abc_29733_new_n9194
* NET  2725 = abc_29733_new_n9193
* NET  2726 = abc_29733_new_n9192
* NET  2727 = abc_29733_new_n9191
* NET  2728 = abc_29733_new_n9190
* NET  2729 = abc_29733_new_n9189
* NET  2730 = abc_29733_new_n9188
* NET  2731 = abc_29733_new_n9186
* NET  2732 = abc_29733_new_n9185
* NET  2733 = abc_29733_new_n9184
* NET  2734 = abc_29733_new_n9182
* NET  2735 = abc_29733_new_n9181
* NET  2736 = abc_29733_new_n9179
* NET  2737 = abc_29733_new_n9178
* NET  2738 = abc_29733_new_n9176
* NET  2739 = abc_29733_new_n9175
* NET  2740 = abc_29733_new_n9174
* NET  2741 = abc_29733_new_n9173
* NET  2742 = abc_29733_new_n9172
* NET  2743 = abc_29733_new_n9171
* NET  2744 = abc_29733_new_n9170
* NET  2745 = abc_29733_new_n9169
* NET  2746 = abc_29733_new_n9168
* NET  2747 = abc_29733_new_n9167
* NET  2748 = abc_29733_new_n9166
* NET  2749 = abc_29733_new_n9165
* NET  2750 = abc_29733_new_n9164
* NET  2751 = abc_29733_new_n9163
* NET  2752 = abc_29733_new_n9162
* NET  2753 = abc_29733_new_n9161
* NET  2754 = abc_29733_new_n9160
* NET  2755 = abc_29733_new_n9159
* NET  2756 = abc_29733_new_n9158
* NET  2757 = abc_29733_new_n9157
* NET  2758 = abc_29733_new_n9156
* NET  2759 = abc_29733_new_n9155
* NET  2760 = abc_29733_new_n9154
* NET  2761 = abc_29733_new_n9153
* NET  2762 = abc_29733_new_n9152
* NET  2763 = abc_29733_new_n9151
* NET  2764 = abc_29733_new_n9150
* NET  2765 = abc_29733_new_n9149
* NET  2766 = abc_29733_new_n9148
* NET  2767 = abc_29733_new_n9147
* NET  2768 = abc_29733_new_n9146
* NET  2769 = abc_29733_new_n9145
* NET  2770 = abc_29733_new_n9144
* NET  2771 = abc_29733_new_n9143
* NET  2772 = abc_29733_new_n9142
* NET  2773 = abc_29733_new_n9141
* NET  2774 = abc_29733_new_n9140
* NET  2775 = abc_29733_new_n9139
* NET  2776 = abc_29733_new_n9138
* NET  2777 = abc_29733_new_n9137
* NET  2778 = abc_29733_new_n9136
* NET  2779 = abc_29733_new_n9135
* NET  2780 = abc_29733_new_n9134
* NET  2781 = abc_29733_new_n9133
* NET  2782 = abc_29733_new_n9131
* NET  2783 = abc_29733_new_n9130
* NET  2784 = abc_29733_new_n9129
* NET  2785 = abc_29733_new_n9128
* NET  2786 = abc_29733_new_n9127
* NET  2787 = abc_29733_new_n9126
* NET  2788 = abc_29733_new_n9125
* NET  2789 = abc_29733_new_n9124
* NET  2790 = abc_29733_new_n9123
* NET  2791 = abc_29733_new_n9122
* NET  2792 = abc_29733_new_n9121
* NET  2793 = abc_29733_new_n9120
* NET  2794 = abc_29733_new_n9119
* NET  2795 = abc_29733_new_n9118
* NET  2796 = abc_29733_new_n9117
* NET  2797 = abc_29733_new_n9116
* NET  2798 = abc_29733_new_n9115
* NET  2799 = abc_29733_new_n9114
* NET  2800 = abc_29733_new_n9113
* NET  2801 = abc_29733_new_n9112
* NET  2802 = abc_29733_new_n9111
* NET  2803 = abc_29733_new_n9110
* NET  2804 = abc_29733_new_n9109
* NET  2805 = abc_29733_new_n9108
* NET  2806 = abc_29733_new_n9107
* NET  2807 = abc_29733_new_n9106
* NET  2808 = abc_29733_new_n9105
* NET  2809 = abc_29733_new_n9104
* NET  2810 = abc_29733_new_n9103
* NET  2811 = abc_29733_new_n9102
* NET  2812 = abc_29733_new_n9101
* NET  2813 = abc_29733_new_n9100
* NET  2814 = abc_29733_new_n9099
* NET  2815 = abc_29733_new_n9098
* NET  2816 = abc_29733_new_n9097
* NET  2817 = abc_29733_new_n9096
* NET  2818 = abc_29733_new_n9095
* NET  2819 = abc_29733_new_n9094
* NET  2820 = abc_29733_new_n9093
* NET  2821 = abc_29733_new_n9092
* NET  2822 = abc_29733_new_n9091
* NET  2823 = abc_29733_new_n9090
* NET  2824 = abc_29733_new_n9089
* NET  2825 = abc_29733_new_n9088
* NET  2826 = abc_29733_new_n9087
* NET  2827 = abc_29733_new_n9085
* NET  2828 = abc_29733_new_n9084
* NET  2829 = abc_29733_new_n9083
* NET  2830 = abc_29733_new_n9082
* NET  2831 = abc_29733_new_n9080
* NET  2832 = abc_29733_new_n9078
* NET  2833 = abc_29733_new_n9077
* NET  2834 = abc_29733_new_n9076
* NET  2835 = abc_29733_new_n9075
* NET  2836 = abc_29733_new_n9074
* NET  2837 = abc_29733_new_n9073
* NET  2838 = abc_29733_new_n9072
* NET  2839 = abc_29733_new_n9071
* NET  2840 = abc_29733_new_n9070
* NET  2841 = abc_29733_new_n9069
* NET  2842 = abc_29733_new_n9068
* NET  2843 = abc_29733_new_n9067
* NET  2844 = abc_29733_new_n9066
* NET  2845 = abc_29733_new_n9065
* NET  2846 = abc_29733_new_n9064
* NET  2847 = abc_29733_new_n9063
* NET  2848 = abc_29733_new_n9062
* NET  2849 = abc_29733_new_n9061
* NET  2850 = abc_29733_new_n9060
* NET  2851 = abc_29733_new_n9059
* NET  2852 = abc_29733_new_n9058
* NET  2853 = abc_29733_new_n9057
* NET  2854 = abc_29733_new_n9056
* NET  2855 = abc_29733_new_n9054
* NET  2856 = abc_29733_new_n9023
* NET  2857 = abc_29733_new_n9022
* NET  2858 = abc_29733_new_n9021
* NET  2859 = abc_29733_new_n9020
* NET  2860 = abc_29733_new_n9019
* NET  2861 = abc_29733_new_n9017
* NET  2862 = abc_29733_new_n9016
* NET  2863 = abc_29733_new_n9015
* NET  2864 = abc_29733_new_n9014
* NET  2865 = abc_29733_new_n9013
* NET  2866 = abc_29733_new_n9012
* NET  2867 = abc_29733_new_n9011
* NET  2868 = abc_29733_new_n9010
* NET  2869 = abc_29733_new_n9009
* NET  2870 = abc_29733_new_n9008
* NET  2871 = abc_29733_new_n9007
* NET  2872 = abc_29733_new_n9006
* NET  2873 = abc_29733_new_n9005
* NET  2874 = abc_29733_new_n9004
* NET  2875 = abc_29733_new_n9003
* NET  2876 = abc_29733_new_n9002
* NET  2877 = abc_29733_new_n9001
* NET  2878 = abc_29733_new_n9000
* NET  2879 = abc_29733_new_n8999
* NET  2880 = abc_29733_new_n8998
* NET  2881 = abc_29733_new_n8997
* NET  2882 = abc_29733_new_n8996
* NET  2883 = abc_29733_new_n8995
* NET  2884 = abc_29733_new_n8994
* NET  2885 = abc_29733_new_n8993
* NET  2886 = abc_29733_new_n8992
* NET  2887 = abc_29733_new_n8991
* NET  2888 = abc_29733_new_n8990
* NET  2889 = abc_29733_new_n8989
* NET  2890 = abc_29733_new_n8988
* NET  2891 = abc_29733_new_n8987
* NET  2892 = abc_29733_new_n8986
* NET  2893 = abc_29733_new_n8985
* NET  2894 = abc_29733_new_n8984
* NET  2895 = abc_29733_new_n8983
* NET  2896 = abc_29733_new_n8982
* NET  2897 = abc_29733_new_n8981
* NET  2898 = abc_29733_new_n8980
* NET  2899 = abc_29733_new_n8979
* NET  2900 = abc_29733_new_n8978
* NET  2901 = abc_29733_new_n8977
* NET  2902 = abc_29733_new_n8976
* NET  2903 = abc_29733_new_n8975
* NET  2904 = abc_29733_new_n8974
* NET  2905 = abc_29733_new_n8973
* NET  2906 = abc_29733_new_n8972
* NET  2907 = abc_29733_new_n8971
* NET  2908 = abc_29733_new_n8970
* NET  2909 = abc_29733_new_n8969
* NET  2910 = abc_29733_new_n8968
* NET  2911 = abc_29733_new_n8967
* NET  2912 = abc_29733_new_n8966
* NET  2913 = abc_29733_new_n8965
* NET  2914 = abc_29733_new_n8964
* NET  2915 = abc_29733_new_n8963
* NET  2916 = abc_29733_new_n8962
* NET  2917 = abc_29733_new_n8961
* NET  2918 = abc_29733_new_n8960
* NET  2919 = abc_29733_new_n8958
* NET  2920 = abc_29733_new_n8956
* NET  2921 = abc_29733_new_n8955
* NET  2922 = abc_29733_new_n8954
* NET  2923 = abc_29733_new_n8952
* NET  2924 = abc_29733_new_n8951
* NET  2925 = abc_29733_new_n8949
* NET  2926 = abc_29733_new_n8948
* NET  2927 = abc_29733_new_n8947
* NET  2928 = abc_29733_new_n8945
* NET  2929 = abc_29733_new_n8944
* NET  2930 = abc_29733_new_n8943
* NET  2931 = abc_29733_new_n8941
* NET  2932 = abc_29733_new_n8940
* NET  2933 = abc_29733_new_n8938
* NET  2934 = abc_29733_new_n8937
* NET  2935 = abc_29733_new_n8936
* NET  2936 = abc_29733_new_n8934
* NET  2937 = abc_29733_new_n8933
* NET  2938 = abc_29733_new_n8932
* NET  2939 = abc_29733_new_n8930
* NET  2940 = abc_29733_new_n8929
* NET  2941 = abc_29733_new_n8927
* NET  2942 = abc_29733_new_n8926
* NET  2943 = abc_29733_new_n8925
* NET  2944 = abc_29733_new_n8923
* NET  2945 = abc_29733_new_n8922
* NET  2946 = abc_29733_new_n8921
* NET  2947 = abc_29733_new_n8919
* NET  2948 = abc_29733_new_n8918
* NET  2949 = abc_29733_new_n8916
* NET  2950 = abc_29733_new_n8915
* NET  2951 = abc_29733_new_n8914
* NET  2952 = abc_29733_new_n8912
* NET  2953 = abc_29733_new_n8911
* NET  2954 = abc_29733_new_n8910
* NET  2955 = abc_29733_new_n8908
* NET  2956 = abc_29733_new_n8907
* NET  2957 = abc_29733_new_n8905
* NET  2958 = abc_29733_new_n8904
* NET  2959 = abc_29733_new_n8903
* NET  2960 = abc_29733_new_n8901
* NET  2961 = abc_29733_new_n8900
* NET  2962 = abc_29733_new_n8899
* NET  2963 = abc_29733_new_n8897
* NET  2964 = abc_29733_new_n8896
* NET  2965 = abc_29733_new_n8894
* NET  2966 = abc_29733_new_n8893
* NET  2967 = abc_29733_new_n8892
* NET  2968 = abc_29733_new_n8890
* NET  2969 = abc_29733_new_n8889
* NET  2970 = abc_29733_new_n8888
* NET  2971 = abc_29733_new_n8886
* NET  2972 = abc_29733_new_n8885
* NET  2973 = abc_29733_new_n8883
* NET  2974 = abc_29733_new_n8882
* NET  2975 = abc_29733_new_n8881
* NET  2976 = abc_29733_new_n8879
* NET  2977 = abc_29733_new_n8878
* NET  2978 = abc_29733_new_n8877
* NET  2979 = abc_29733_new_n8875
* NET  2980 = abc_29733_new_n8874
* NET  2981 = abc_29733_new_n8872
* NET  2982 = abc_29733_new_n8871
* NET  2983 = abc_29733_new_n8870
* NET  2984 = abc_29733_new_n8868
* NET  2985 = abc_29733_new_n8867
* NET  2986 = abc_29733_new_n8866
* NET  2987 = abc_29733_new_n8864
* NET  2988 = abc_29733_new_n8863
* NET  2989 = abc_29733_new_n8861
* NET  2990 = abc_29733_new_n8860
* NET  2991 = abc_29733_new_n8859
* NET  2992 = abc_29733_new_n8857
* NET  2993 = abc_29733_new_n8856
* NET  2994 = abc_29733_new_n8855
* NET  2995 = abc_29733_new_n8853
* NET  2996 = abc_29733_new_n8852
* NET  2997 = abc_29733_new_n8850
* NET  2998 = abc_29733_new_n8849
* NET  2999 = abc_29733_new_n8848
* NET  3000 = abc_29733_new_n8846
* NET  3001 = abc_29733_new_n8845
* NET  3002 = abc_29733_new_n8844
* NET  3003 = abc_29733_new_n8842
* NET  3004 = abc_29733_new_n8841
* NET  3005 = abc_29733_new_n8839
* NET  3006 = abc_29733_new_n8838
* NET  3007 = abc_29733_new_n8837
* NET  3008 = abc_29733_new_n8835
* NET  3009 = abc_29733_new_n8834
* NET  3010 = abc_29733_new_n8833
* NET  3011 = abc_29733_new_n8831
* NET  3012 = abc_29733_new_n8830
* NET  3013 = abc_29733_new_n8828
* NET  3014 = abc_29733_new_n8827
* NET  3015 = abc_29733_new_n8826
* NET  3016 = abc_29733_new_n8824
* NET  3017 = abc_29733_new_n8823
* NET  3018 = abc_29733_new_n8822
* NET  3019 = abc_29733_new_n8820
* NET  3020 = abc_29733_new_n8819
* NET  3021 = abc_29733_new_n8817
* NET  3022 = abc_29733_new_n8816
* NET  3023 = abc_29733_new_n8815
* NET  3024 = abc_29733_new_n8813
* NET  3025 = abc_29733_new_n8812
* NET  3026 = abc_29733_new_n8811
* NET  3027 = abc_29733_new_n8809
* NET  3028 = abc_29733_new_n8808
* NET  3029 = abc_29733_new_n8806
* NET  3030 = abc_29733_new_n8805
* NET  3031 = abc_29733_new_n8804
* NET  3032 = abc_29733_new_n8802
* NET  3033 = abc_29733_new_n8801
* NET  3034 = abc_29733_new_n8800
* NET  3035 = abc_29733_new_n8798
* NET  3036 = abc_29733_new_n8797
* NET  3037 = abc_29733_new_n8795
* NET  3038 = abc_29733_new_n8794
* NET  3039 = abc_29733_new_n8793
* NET  3040 = abc_29733_new_n8791
* NET  3041 = abc_29733_new_n8790
* NET  3042 = abc_29733_new_n8789
* NET  3043 = abc_29733_new_n8787
* NET  3044 = abc_29733_new_n8786
* NET  3045 = abc_29733_new_n8784
* NET  3046 = abc_29733_new_n8783
* NET  3047 = abc_29733_new_n8782
* NET  3048 = abc_29733_new_n8780
* NET  3049 = abc_29733_new_n8779
* NET  3050 = abc_29733_new_n8778
* NET  3051 = abc_29733_new_n8776
* NET  3052 = abc_29733_new_n8775
* NET  3053 = abc_29733_new_n8773
* NET  3054 = abc_29733_new_n8772
* NET  3055 = abc_29733_new_n8771
* NET  3056 = abc_29733_new_n8769
* NET  3057 = abc_29733_new_n8768
* NET  3058 = abc_29733_new_n8767
* NET  3059 = abc_29733_new_n8765
* NET  3060 = abc_29733_new_n8764
* NET  3061 = abc_29733_new_n8762
* NET  3062 = abc_29733_new_n8761
* NET  3063 = abc_29733_new_n8760
* NET  3064 = abc_29733_new_n8758
* NET  3065 = abc_29733_new_n8757
* NET  3066 = abc_29733_new_n8756
* NET  3067 = abc_29733_new_n8754
* NET  3068 = abc_29733_new_n8753
* NET  3069 = abc_29733_new_n8751
* NET  3070 = abc_29733_new_n8750
* NET  3071 = abc_29733_new_n8749
* NET  3072 = abc_29733_new_n8747
* NET  3073 = abc_29733_new_n8746
* NET  3074 = abc_29733_new_n8745
* NET  3075 = abc_29733_new_n8743
* NET  3076 = abc_29733_new_n8742
* NET  3077 = abc_29733_new_n8740
* NET  3078 = abc_29733_new_n8739
* NET  3079 = abc_29733_new_n8738
* NET  3080 = abc_29733_new_n8736
* NET  3081 = abc_29733_new_n8735
* NET  3082 = abc_29733_new_n8734
* NET  3083 = abc_29733_new_n8732
* NET  3084 = abc_29733_new_n8731
* NET  3085 = abc_29733_new_n8728
* NET  3086 = abc_29733_new_n8727
* NET  3087 = abc_29733_new_n8726
* NET  3088 = abc_29733_new_n8725
* NET  3089 = abc_29733_new_n8724
* NET  3090 = abc_29733_new_n8723
* NET  3091 = abc_29733_new_n8722
* NET  3092 = abc_29733_new_n8721
* NET  3093 = abc_29733_new_n8720
* NET  3094 = abc_29733_new_n8719
* NET  3095 = abc_29733_new_n8717
* NET  3096 = abc_29733_new_n8716
* NET  3097 = abc_29733_new_n8715
* NET  3098 = abc_29733_new_n8714
* NET  3099 = abc_29733_new_n8713
* NET  3100 = abc_29733_new_n8712
* NET  3101 = abc_29733_new_n8711
* NET  3102 = abc_29733_new_n8710
* NET  3103 = abc_29733_new_n8709
* NET  3104 = abc_29733_new_n8708
* NET  3105 = abc_29733_new_n8707
* NET  3106 = abc_29733_new_n8705
* NET  3107 = abc_29733_new_n8704
* NET  3108 = abc_29733_new_n8703
* NET  3109 = abc_29733_new_n8702
* NET  3110 = abc_29733_new_n8701
* NET  3111 = abc_29733_new_n8700
* NET  3112 = abc_29733_new_n8699
* NET  3113 = abc_29733_new_n8698
* NET  3114 = abc_29733_new_n8697
* NET  3115 = abc_29733_new_n8696
* NET  3116 = abc_29733_new_n8695
* NET  3117 = abc_29733_new_n8694
* NET  3118 = abc_29733_new_n8693
* NET  3119 = abc_29733_new_n8692
* NET  3120 = abc_29733_new_n8691
* NET  3121 = abc_29733_new_n8690
* NET  3122 = abc_29733_new_n8689
* NET  3123 = abc_29733_new_n8687
* NET  3124 = abc_29733_new_n8686
* NET  3125 = abc_29733_new_n8685
* NET  3126 = abc_29733_new_n8684
* NET  3127 = abc_29733_new_n8683
* NET  3128 = abc_29733_new_n8682
* NET  3129 = abc_29733_new_n8681
* NET  3130 = abc_29733_new_n8680
* NET  3131 = abc_29733_new_n8679
* NET  3132 = abc_29733_new_n8678
* NET  3133 = abc_29733_new_n8677
* NET  3134 = abc_29733_new_n8675
* NET  3135 = abc_29733_new_n8674
* NET  3136 = abc_29733_new_n8673
* NET  3137 = abc_29733_new_n8672
* NET  3138 = abc_29733_new_n8671
* NET  3139 = abc_29733_new_n8670
* NET  3140 = abc_29733_new_n8669
* NET  3141 = abc_29733_new_n8668
* NET  3142 = abc_29733_new_n8667
* NET  3143 = abc_29733_new_n8666
* NET  3144 = abc_29733_new_n8665
* NET  3145 = abc_29733_new_n8664
* NET  3146 = abc_29733_new_n8663
* NET  3147 = abc_29733_new_n8662
* NET  3148 = abc_29733_new_n8660
* NET  3149 = abc_29733_new_n8659
* NET  3150 = abc_29733_new_n8658
* NET  3151 = abc_29733_new_n8657
* NET  3152 = abc_29733_new_n8656
* NET  3153 = abc_29733_new_n8655
* NET  3154 = abc_29733_new_n8654
* NET  3155 = abc_29733_new_n8653
* NET  3156 = abc_29733_new_n8652
* NET  3157 = abc_29733_new_n8651
* NET  3158 = abc_29733_new_n8650
* NET  3159 = abc_29733_new_n8648
* NET  3160 = abc_29733_new_n8647
* NET  3161 = abc_29733_new_n8646
* NET  3162 = abc_29733_new_n8645
* NET  3163 = abc_29733_new_n8644
* NET  3164 = abc_29733_new_n8643
* NET  3165 = abc_29733_new_n8642
* NET  3166 = abc_29733_new_n8641
* NET  3167 = abc_29733_new_n8640
* NET  3168 = abc_29733_new_n8639
* NET  3169 = abc_29733_new_n8638
* NET  3170 = abc_29733_new_n8637
* NET  3171 = abc_29733_new_n8636
* NET  3172 = abc_29733_new_n8635
* NET  3173 = abc_29733_new_n8634
* NET  3174 = abc_29733_new_n8633
* NET  3175 = abc_29733_new_n8632
* NET  3176 = abc_29733_new_n8631
* NET  3177 = abc_29733_new_n8630
* NET  3178 = abc_29733_new_n8629
* NET  3179 = abc_29733_new_n8628
* NET  3180 = abc_29733_new_n8626
* NET  3181 = abc_29733_new_n8625
* NET  3182 = abc_29733_new_n8624
* NET  3183 = abc_29733_new_n8623
* NET  3184 = abc_29733_new_n8622
* NET  3185 = abc_29733_new_n8621
* NET  3186 = abc_29733_new_n8620
* NET  3187 = abc_29733_new_n8619
* NET  3188 = abc_29733_new_n8618
* NET  3189 = abc_29733_new_n8617
* NET  3190 = abc_29733_new_n8616
* NET  3191 = abc_29733_new_n8614
* NET  3192 = abc_29733_new_n8613
* NET  3193 = abc_29733_new_n8612
* NET  3194 = abc_29733_new_n8611
* NET  3195 = abc_29733_new_n8610
* NET  3196 = abc_29733_new_n8609
* NET  3197 = abc_29733_new_n8608
* NET  3198 = abc_29733_new_n8607
* NET  3199 = abc_29733_new_n8606
* NET  3200 = abc_29733_new_n8605
* NET  3201 = abc_29733_new_n8604
* NET  3202 = abc_29733_new_n8603
* NET  3203 = abc_29733_new_n8602
* NET  3204 = abc_29733_new_n8601
* NET  3205 = abc_29733_new_n8600
* NET  3206 = abc_29733_new_n8599
* NET  3207 = abc_29733_new_n8598
* NET  3208 = abc_29733_new_n8596
* NET  3209 = abc_29733_new_n8595
* NET  3210 = abc_29733_new_n8594
* NET  3211 = abc_29733_new_n8593
* NET  3212 = abc_29733_new_n8592
* NET  3213 = abc_29733_new_n8591
* NET  3214 = abc_29733_new_n8590
* NET  3215 = abc_29733_new_n8589
* NET  3216 = abc_29733_new_n8588
* NET  3217 = abc_29733_new_n8587
* NET  3218 = abc_29733_new_n8586
* NET  3219 = abc_29733_new_n8584
* NET  3220 = abc_29733_new_n8583
* NET  3221 = abc_29733_new_n8582
* NET  3222 = abc_29733_new_n8581
* NET  3223 = abc_29733_new_n8580
* NET  3224 = abc_29733_new_n8579
* NET  3225 = abc_29733_new_n8578
* NET  3226 = abc_29733_new_n8577
* NET  3227 = abc_29733_new_n8576
* NET  3228 = abc_29733_new_n8575
* NET  3229 = abc_29733_new_n8574
* NET  3230 = abc_29733_new_n8573
* NET  3231 = abc_29733_new_n8572
* NET  3232 = abc_29733_new_n8570
* NET  3233 = abc_29733_new_n8569
* NET  3234 = abc_29733_new_n8568
* NET  3235 = abc_29733_new_n8567
* NET  3236 = abc_29733_new_n8566
* NET  3237 = abc_29733_new_n8565
* NET  3238 = abc_29733_new_n8564
* NET  3239 = abc_29733_new_n8563
* NET  3240 = abc_29733_new_n8562
* NET  3241 = abc_29733_new_n8561
* NET  3242 = abc_29733_new_n8560
* NET  3243 = abc_29733_new_n8558
* NET  3244 = abc_29733_new_n8557
* NET  3245 = abc_29733_new_n8556
* NET  3246 = abc_29733_new_n8555
* NET  3247 = abc_29733_new_n8554
* NET  3248 = abc_29733_new_n8553
* NET  3249 = abc_29733_new_n8552
* NET  3250 = abc_29733_new_n8551
* NET  3251 = abc_29733_new_n8550
* NET  3252 = abc_29733_new_n8549
* NET  3253 = abc_29733_new_n8548
* NET  3254 = abc_29733_new_n8547
* NET  3255 = abc_29733_new_n8545
* NET  3256 = abc_29733_new_n8544
* NET  3257 = abc_29733_new_n8543
* NET  3258 = abc_29733_new_n8542
* NET  3259 = abc_29733_new_n8541
* NET  3260 = abc_29733_new_n8540
* NET  3261 = abc_29733_new_n8539
* NET  3262 = abc_29733_new_n8538
* NET  3263 = abc_29733_new_n8537
* NET  3264 = abc_29733_new_n8536
* NET  3265 = abc_29733_new_n8535
* NET  3266 = abc_29733_new_n8533
* NET  3267 = abc_29733_new_n8532
* NET  3268 = abc_29733_new_n8531
* NET  3269 = abc_29733_new_n8530
* NET  3270 = abc_29733_new_n8529
* NET  3271 = abc_29733_new_n8528
* NET  3272 = abc_29733_new_n8527
* NET  3273 = abc_29733_new_n8526
* NET  3274 = abc_29733_new_n8525
* NET  3275 = abc_29733_new_n8524
* NET  3276 = abc_29733_new_n8523
* NET  3277 = abc_29733_new_n8522
* NET  3278 = abc_29733_new_n8520
* NET  3279 = abc_29733_new_n8519
* NET  3280 = abc_29733_new_n8518
* NET  3281 = abc_29733_new_n8517
* NET  3282 = abc_29733_new_n8516
* NET  3283 = abc_29733_new_n8515
* NET  3284 = abc_29733_new_n8514
* NET  3285 = abc_29733_new_n8513
* NET  3286 = abc_29733_new_n8512
* NET  3287 = abc_29733_new_n8511
* NET  3288 = abc_29733_new_n8510
* NET  3289 = abc_29733_new_n8508
* NET  3290 = abc_29733_new_n8507
* NET  3291 = abc_29733_new_n8506
* NET  3292 = abc_29733_new_n8505
* NET  3293 = abc_29733_new_n8504
* NET  3294 = abc_29733_new_n8503
* NET  3295 = abc_29733_new_n8502
* NET  3296 = abc_29733_new_n8501
* NET  3297 = abc_29733_new_n8500
* NET  3298 = abc_29733_new_n8499
* NET  3299 = abc_29733_new_n8498
* NET  3300 = abc_29733_new_n8497
* NET  3301 = abc_29733_new_n8495
* NET  3302 = abc_29733_new_n8494
* NET  3303 = abc_29733_new_n8493
* NET  3304 = abc_29733_new_n8492
* NET  3305 = abc_29733_new_n8491
* NET  3306 = abc_29733_new_n8490
* NET  3307 = abc_29733_new_n8489
* NET  3308 = abc_29733_new_n8488
* NET  3309 = abc_29733_new_n8487
* NET  3310 = abc_29733_new_n8486
* NET  3311 = abc_29733_new_n8485
* NET  3312 = abc_29733_new_n8483
* NET  3313 = abc_29733_new_n8482
* NET  3314 = abc_29733_new_n8481
* NET  3315 = abc_29733_new_n8480
* NET  3316 = abc_29733_new_n8479
* NET  3317 = abc_29733_new_n8478
* NET  3318 = abc_29733_new_n8477
* NET  3319 = abc_29733_new_n8476
* NET  3320 = abc_29733_new_n8475
* NET  3321 = abc_29733_new_n8474
* NET  3322 = abc_29733_new_n8473
* NET  3323 = abc_29733_new_n8472
* NET  3324 = abc_29733_new_n8470
* NET  3325 = abc_29733_new_n8469
* NET  3326 = abc_29733_new_n8468
* NET  3327 = abc_29733_new_n8467
* NET  3328 = abc_29733_new_n8466
* NET  3329 = abc_29733_new_n8465
* NET  3330 = abc_29733_new_n8464
* NET  3331 = abc_29733_new_n8463
* NET  3332 = abc_29733_new_n8462
* NET  3333 = abc_29733_new_n8461
* NET  3334 = abc_29733_new_n8460
* NET  3335 = abc_29733_new_n8458
* NET  3336 = abc_29733_new_n8457
* NET  3337 = abc_29733_new_n8456
* NET  3338 = abc_29733_new_n8455
* NET  3339 = abc_29733_new_n8454
* NET  3340 = abc_29733_new_n8453
* NET  3341 = abc_29733_new_n8452
* NET  3342 = abc_29733_new_n8451
* NET  3343 = abc_29733_new_n8450
* NET  3344 = abc_29733_new_n8449
* NET  3345 = abc_29733_new_n8448
* NET  3346 = abc_29733_new_n8447
* NET  3347 = abc_29733_new_n8445
* NET  3348 = abc_29733_new_n8444
* NET  3349 = abc_29733_new_n8443
* NET  3350 = abc_29733_new_n8442
* NET  3351 = abc_29733_new_n8441
* NET  3352 = abc_29733_new_n8440
* NET  3353 = abc_29733_new_n8439
* NET  3354 = abc_29733_new_n8438
* NET  3355 = abc_29733_new_n8437
* NET  3356 = abc_29733_new_n8436
* NET  3357 = abc_29733_new_n8435
* NET  3358 = abc_29733_new_n8433
* NET  3359 = abc_29733_new_n8432
* NET  3360 = abc_29733_new_n8431
* NET  3361 = abc_29733_new_n8430
* NET  3362 = abc_29733_new_n8429
* NET  3363 = abc_29733_new_n8428
* NET  3364 = abc_29733_new_n8427
* NET  3365 = abc_29733_new_n8426
* NET  3366 = abc_29733_new_n8425
* NET  3367 = abc_29733_new_n8424
* NET  3368 = abc_29733_new_n8423
* NET  3369 = abc_29733_new_n8422
* NET  3370 = abc_29733_new_n8420
* NET  3371 = abc_29733_new_n8419
* NET  3372 = abc_29733_new_n8418
* NET  3373 = abc_29733_new_n8417
* NET  3374 = abc_29733_new_n8416
* NET  3375 = abc_29733_new_n8415
* NET  3376 = abc_29733_new_n8414
* NET  3377 = abc_29733_new_n8413
* NET  3378 = abc_29733_new_n8412
* NET  3379 = abc_29733_new_n8411
* NET  3380 = abc_29733_new_n8410
* NET  3381 = abc_29733_new_n8408
* NET  3382 = abc_29733_new_n8407
* NET  3383 = abc_29733_new_n8406
* NET  3384 = abc_29733_new_n8405
* NET  3385 = abc_29733_new_n8404
* NET  3386 = abc_29733_new_n8403
* NET  3387 = abc_29733_new_n8402
* NET  3388 = abc_29733_new_n8401
* NET  3389 = abc_29733_new_n8400
* NET  3390 = abc_29733_new_n8399
* NET  3391 = abc_29733_new_n8398
* NET  3392 = abc_29733_new_n8396
* NET  3393 = abc_29733_new_n8395
* NET  3394 = abc_29733_new_n8394
* NET  3395 = abc_29733_new_n8393
* NET  3396 = abc_29733_new_n8392
* NET  3397 = abc_29733_new_n8391
* NET  3398 = abc_29733_new_n8390
* NET  3399 = abc_29733_new_n8389
* NET  3400 = abc_29733_new_n8388
* NET  3401 = abc_29733_new_n8387
* NET  3402 = abc_29733_new_n8386
* NET  3403 = abc_29733_new_n8384
* NET  3404 = abc_29733_new_n8383
* NET  3405 = abc_29733_new_n8382
* NET  3406 = abc_29733_new_n8381
* NET  3407 = abc_29733_new_n8380
* NET  3408 = abc_29733_new_n8379
* NET  3409 = abc_29733_new_n8378
* NET  3410 = abc_29733_new_n8377
* NET  3411 = abc_29733_new_n8376
* NET  3412 = abc_29733_new_n8375
* NET  3413 = abc_29733_new_n8374
* NET  3414 = abc_29733_new_n8372
* NET  3415 = abc_29733_new_n8371
* NET  3416 = abc_29733_new_n8370
* NET  3417 = abc_29733_new_n8369
* NET  3418 = abc_29733_new_n8368
* NET  3419 = abc_29733_new_n8367
* NET  3420 = abc_29733_new_n8366
* NET  3421 = abc_29733_new_n8365
* NET  3422 = abc_29733_new_n8364
* NET  3423 = abc_29733_new_n8363
* NET  3424 = abc_29733_new_n8362
* NET  3425 = abc_29733_new_n8361
* NET  3426 = abc_29733_new_n8360
* NET  3427 = abc_29733_new_n8359
* NET  3428 = abc_29733_new_n8357
* NET  3429 = abc_29733_new_n8356
* NET  3430 = abc_29733_new_n8355
* NET  3431 = abc_29733_new_n8354
* NET  3432 = abc_29733_new_n8353
* NET  3433 = abc_29733_new_n8352
* NET  3434 = abc_29733_new_n8351
* NET  3435 = abc_29733_new_n8350
* NET  3436 = abc_29733_new_n8349
* NET  3437 = abc_29733_new_n8348
* NET  3438 = abc_29733_new_n8347
* NET  3439 = abc_29733_new_n8345
* NET  3440 = abc_29733_new_n8344
* NET  3441 = abc_29733_new_n8343
* NET  3442 = abc_29733_new_n8342
* NET  3443 = abc_29733_new_n8341
* NET  3444 = abc_29733_new_n8340
* NET  3445 = abc_29733_new_n8339
* NET  3446 = abc_29733_new_n8337
* NET  3447 = abc_29733_new_n8336
* NET  3448 = abc_29733_new_n8335
* NET  3449 = abc_29733_new_n8334
* NET  3450 = abc_29733_new_n8333
* NET  3451 = abc_29733_new_n8332
* NET  3452 = abc_29733_new_n8331
* NET  3453 = abc_29733_new_n8329
* NET  3454 = abc_29733_new_n8328
* NET  3455 = abc_29733_new_n8327
* NET  3456 = abc_29733_new_n8325
* NET  3457 = abc_29733_new_n8324
* NET  3458 = abc_29733_new_n8323
* NET  3459 = abc_29733_new_n8321
* NET  3460 = abc_29733_new_n8320
* NET  3461 = abc_29733_new_n8319
* NET  3462 = abc_29733_new_n8317
* NET  3463 = abc_29733_new_n8316
* NET  3464 = abc_29733_new_n8315
* NET  3465 = abc_29733_new_n8313
* NET  3466 = abc_29733_new_n8312
* NET  3467 = abc_29733_new_n8311
* NET  3468 = abc_29733_new_n8309
* NET  3469 = abc_29733_new_n8308
* NET  3470 = abc_29733_new_n8307
* NET  3471 = abc_29733_new_n8305
* NET  3472 = abc_29733_new_n8304
* NET  3473 = abc_29733_new_n8303
* NET  3474 = abc_29733_new_n8301
* NET  3475 = abc_29733_new_n8300
* NET  3476 = abc_29733_new_n8299
* NET  3477 = abc_29733_new_n8297
* NET  3478 = abc_29733_new_n8296
* NET  3479 = abc_29733_new_n8295
* NET  3480 = abc_29733_new_n8293
* NET  3481 = abc_29733_new_n8292
* NET  3482 = abc_29733_new_n8291
* NET  3483 = abc_29733_new_n8289
* NET  3484 = abc_29733_new_n8288
* NET  3485 = abc_29733_new_n8287
* NET  3486 = abc_29733_new_n8285
* NET  3487 = abc_29733_new_n8284
* NET  3488 = abc_29733_new_n8283
* NET  3489 = abc_29733_new_n8281
* NET  3490 = abc_29733_new_n8280
* NET  3491 = abc_29733_new_n8279
* NET  3492 = abc_29733_new_n8277
* NET  3493 = abc_29733_new_n8276
* NET  3494 = abc_29733_new_n8275
* NET  3495 = abc_29733_new_n8273
* NET  3496 = abc_29733_new_n8272
* NET  3497 = abc_29733_new_n8271
* NET  3498 = abc_29733_new_n8269
* NET  3499 = abc_29733_new_n8268
* NET  3500 = abc_29733_new_n8267
* NET  3501 = abc_29733_new_n8265
* NET  3502 = abc_29733_new_n8264
* NET  3503 = abc_29733_new_n8263
* NET  3504 = abc_29733_new_n8261
* NET  3505 = abc_29733_new_n8260
* NET  3506 = abc_29733_new_n8259
* NET  3507 = abc_29733_new_n8257
* NET  3508 = abc_29733_new_n8256
* NET  3509 = abc_29733_new_n8255
* NET  3510 = abc_29733_new_n8253
* NET  3511 = abc_29733_new_n8252
* NET  3512 = abc_29733_new_n8251
* NET  3513 = abc_29733_new_n8249
* NET  3514 = abc_29733_new_n8248
* NET  3515 = abc_29733_new_n8247
* NET  3516 = abc_29733_new_n8245
* NET  3517 = abc_29733_new_n8244
* NET  3518 = abc_29733_new_n8243
* NET  3519 = abc_29733_new_n8241
* NET  3520 = abc_29733_new_n8240
* NET  3521 = abc_29733_new_n8239
* NET  3522 = abc_29733_new_n8237
* NET  3523 = abc_29733_new_n8236
* NET  3524 = abc_29733_new_n8235
* NET  3525 = abc_29733_new_n8233
* NET  3526 = abc_29733_new_n8232
* NET  3527 = abc_29733_new_n8231
* NET  3528 = abc_29733_new_n8229
* NET  3529 = abc_29733_new_n8228
* NET  3530 = abc_29733_new_n8227
* NET  3531 = abc_29733_new_n8225
* NET  3532 = abc_29733_new_n8224
* NET  3533 = abc_29733_new_n8223
* NET  3534 = abc_29733_new_n8221
* NET  3535 = abc_29733_new_n8220
* NET  3536 = abc_29733_new_n8219
* NET  3537 = abc_29733_new_n8217
* NET  3538 = abc_29733_new_n8216
* NET  3539 = abc_29733_new_n8215
* NET  3540 = abc_29733_new_n8213
* NET  3541 = abc_29733_new_n8212
* NET  3542 = abc_29733_new_n8211
* NET  3543 = abc_29733_new_n8209
* NET  3544 = abc_29733_new_n8208
* NET  3545 = abc_29733_new_n8207
* NET  3546 = abc_29733_new_n8205
* NET  3547 = abc_29733_new_n8204
* NET  3548 = abc_29733_new_n8202
* NET  3549 = abc_29733_new_n8201
* NET  3550 = abc_29733_new_n8200
* NET  3551 = abc_29733_new_n8198
* NET  3552 = abc_29733_new_n8197
* NET  3553 = abc_29733_new_n8195
* NET  3554 = abc_29733_new_n8194
* NET  3555 = abc_29733_new_n8193
* NET  3556 = abc_29733_new_n8191
* NET  3557 = abc_29733_new_n8190
* NET  3558 = abc_29733_new_n8189
* NET  3559 = abc_29733_new_n8187
* NET  3560 = abc_29733_new_n8186
* NET  3561 = abc_29733_new_n8184
* NET  3562 = abc_29733_new_n8183
* NET  3563 = abc_29733_new_n8182
* NET  3564 = abc_29733_new_n8180
* NET  3565 = abc_29733_new_n8179
* NET  3566 = abc_29733_new_n8177
* NET  3567 = abc_29733_new_n8176
* NET  3568 = abc_29733_new_n8175
* NET  3569 = abc_29733_new_n8173
* NET  3570 = abc_29733_new_n8172
* NET  3571 = abc_29733_new_n8171
* NET  3572 = abc_29733_new_n8170
* NET  3573 = abc_29733_new_n8169
* NET  3574 = abc_29733_new_n8168
* NET  3575 = abc_29733_new_n8166
* NET  3576 = abc_29733_new_n8165
* NET  3577 = abc_29733_new_n8163
* NET  3578 = abc_29733_new_n8162
* NET  3579 = abc_29733_new_n8161
* NET  3580 = abc_29733_new_n8160
* NET  3581 = abc_29733_new_n8159
* NET  3582 = abc_29733_new_n8157
* NET  3583 = abc_29733_new_n8156
* NET  3584 = abc_29733_new_n8155
* NET  3585 = abc_29733_new_n8153
* NET  3586 = abc_29733_new_n8152
* NET  3587 = abc_29733_new_n8151
* NET  3588 = abc_29733_new_n8149
* NET  3589 = abc_29733_new_n8148
* NET  3590 = abc_29733_new_n8146
* NET  3591 = abc_29733_new_n8145
* NET  3592 = abc_29733_new_n8144
* NET  3593 = abc_29733_new_n8143
* NET  3594 = abc_29733_new_n8142
* NET  3595 = abc_29733_new_n8141
* NET  3596 = abc_29733_new_n8139
* NET  3597 = abc_29733_new_n8138
* NET  3598 = abc_29733_new_n8136
* NET  3599 = abc_29733_new_n8135
* NET  3600 = abc_29733_new_n8133
* NET  3601 = abc_29733_new_n8132
* NET  3602 = abc_29733_new_n8131
* NET  3603 = abc_29733_new_n8129
* NET  3604 = abc_29733_new_n8128
* NET  3605 = abc_29733_new_n8127
* NET  3606 = abc_29733_new_n8126
* NET  3607 = abc_29733_new_n8124
* NET  3608 = abc_29733_new_n8123
* NET  3609 = abc_29733_new_n8121
* NET  3610 = abc_29733_new_n8120
* NET  3611 = abc_29733_new_n8119
* NET  3612 = abc_29733_new_n8117
* NET  3613 = abc_29733_new_n8116
* NET  3614 = abc_29733_new_n8115
* NET  3615 = abc_29733_new_n8114
* NET  3616 = abc_29733_new_n8112
* NET  3617 = abc_29733_new_n8111
* NET  3618 = abc_29733_new_n8110
* NET  3619 = abc_29733_new_n8108
* NET  3620 = abc_29733_new_n8107
* NET  3621 = abc_29733_new_n8105
* NET  3622 = abc_29733_new_n8104
* NET  3623 = abc_29733_new_n8103
* NET  3624 = abc_29733_new_n8101
* NET  3625 = abc_29733_new_n8100
* NET  3626 = abc_29733_new_n8099
* NET  3627 = abc_29733_new_n8098
* NET  3628 = abc_29733_new_n8096
* NET  3629 = abc_29733_new_n8095
* NET  3630 = abc_29733_new_n8094
* NET  3631 = abc_29733_new_n8093
* NET  3632 = abc_29733_new_n8092
* NET  3633 = abc_29733_new_n8091
* NET  3634 = abc_29733_new_n8090
* NET  3635 = abc_29733_new_n8088
* NET  3636 = abc_29733_new_n8087
* NET  3637 = abc_29733_new_n8085
* NET  3638 = abc_29733_new_n8084
* NET  3639 = abc_29733_new_n8082
* NET  3640 = abc_29733_new_n8081
* NET  3641 = abc_29733_new_n8079
* NET  3642 = abc_29733_new_n8078
* NET  3643 = abc_29733_new_n8077
* NET  3644 = abc_29733_new_n8075
* NET  3645 = abc_29733_new_n8074
* NET  3646 = abc_29733_new_n8073
* NET  3647 = abc_29733_new_n8072
* NET  3648 = abc_29733_new_n8070
* NET  3649 = abc_29733_new_n8069
* NET  3650 = abc_29733_new_n8068
* NET  3651 = abc_29733_new_n8067
* NET  3652 = abc_29733_new_n8065
* NET  3653 = abc_29733_new_n8064
* NET  3654 = abc_29733_new_n8063
* NET  3655 = abc_29733_new_n8061
* NET  3656 = abc_29733_new_n8060
* NET  3657 = abc_29733_new_n8059
* NET  3658 = abc_29733_new_n8058
* NET  3659 = abc_29733_new_n8056
* NET  3660 = abc_29733_new_n8055
* NET  3661 = abc_29733_new_n8053
* NET  3662 = abc_29733_new_n8052
* NET  3663 = abc_29733_new_n8051
* NET  3664 = abc_29733_new_n8049
* NET  3665 = abc_29733_new_n8048
* NET  3666 = abc_29733_new_n8046
* NET  3667 = abc_29733_new_n8045
* NET  3668 = abc_29733_new_n8044
* NET  3669 = abc_29733_new_n8043
* NET  3670 = abc_29733_new_n8042
* NET  3671 = abc_29733_new_n8041
* NET  3672 = abc_29733_new_n8040
* NET  3673 = abc_29733_new_n8038
* NET  3674 = abc_29733_new_n8037
* NET  3675 = abc_29733_new_n8036
* NET  3676 = abc_29733_new_n8035
* NET  3677 = abc_29733_new_n8034
* NET  3678 = abc_29733_new_n8032
* NET  3679 = abc_29733_new_n8031
* NET  3680 = abc_29733_new_n8029
* NET  3681 = abc_29733_new_n8028
* NET  3682 = abc_29733_new_n8027
* NET  3683 = abc_29733_new_n8025
* NET  3684 = abc_29733_new_n8024
* NET  3685 = abc_29733_new_n8022
* NET  3686 = abc_29733_new_n8021
* NET  3687 = abc_29733_new_n8020
* NET  3688 = abc_29733_new_n8019
* NET  3689 = abc_29733_new_n8018
* NET  3690 = abc_29733_new_n8016
* NET  3691 = abc_29733_new_n8015
* NET  3692 = abc_29733_new_n8013
* NET  3693 = abc_29733_new_n8012
* NET  3694 = abc_29733_new_n8011
* NET  3695 = abc_29733_new_n8009
* NET  3696 = abc_29733_new_n8008
* NET  3697 = abc_29733_new_n8007
* NET  3698 = abc_29733_new_n8006
* NET  3699 = abc_29733_new_n8004
* NET  3700 = abc_29733_new_n8003
* NET  3701 = abc_29733_new_n8002
* NET  3702 = abc_29733_new_n8001
* NET  3703 = abc_29733_new_n7999
* NET  3704 = abc_29733_new_n7998
* NET  3705 = abc_29733_new_n7997
* NET  3706 = abc_29733_new_n7996
* NET  3707 = abc_29733_new_n7995
* NET  3708 = abc_29733_new_n7994
* NET  3709 = abc_29733_new_n7993
* NET  3710 = abc_29733_new_n7992
* NET  3711 = abc_29733_new_n7991
* NET  3712 = abc_29733_new_n7990
* NET  3713 = abc_29733_new_n7989
* NET  3714 = abc_29733_new_n7988
* NET  3715 = abc_29733_new_n7987
* NET  3716 = abc_29733_new_n7986
* NET  3717 = abc_29733_new_n7985
* NET  3718 = abc_29733_new_n7984
* NET  3719 = abc_29733_new_n7983
* NET  3720 = abc_29733_new_n7982
* NET  3721 = abc_29733_new_n7980
* NET  3722 = abc_29733_new_n7979
* NET  3723 = abc_29733_new_n7978
* NET  3724 = abc_29733_new_n7976
* NET  3725 = abc_29733_new_n7975
* NET  3726 = abc_29733_new_n7973
* NET  3727 = abc_29733_new_n7972
* NET  3728 = abc_29733_new_n7971
* NET  3729 = abc_29733_new_n7970
* NET  3730 = abc_29733_new_n7968
* NET  3731 = abc_29733_new_n7967
* NET  3732 = abc_29733_new_n7966
* NET  3733 = abc_29733_new_n7964
* NET  3734 = abc_29733_new_n7963
* NET  3735 = abc_29733_new_n7962
* NET  3736 = abc_29733_new_n7961
* NET  3737 = abc_29733_new_n7959
* NET  3738 = abc_29733_new_n7958
* NET  3739 = abc_29733_new_n7956
* NET  3740 = abc_29733_new_n7955
* NET  3741 = abc_29733_new_n7954
* NET  3742 = abc_29733_new_n7953
* NET  3743 = abc_29733_new_n7951
* NET  3744 = abc_29733_new_n7950
* NET  3745 = abc_29733_new_n7949
* NET  3746 = abc_29733_new_n7947
* NET  3747 = abc_29733_new_n7946
* NET  3748 = abc_29733_new_n7945
* NET  3749 = abc_29733_new_n7944
* NET  3750 = abc_29733_new_n7942
* NET  3751 = abc_29733_new_n7941
* NET  3752 = abc_29733_new_n7940
* NET  3753 = abc_29733_new_n7938
* NET  3754 = abc_29733_new_n7937
* NET  3755 = abc_29733_new_n7936
* NET  3756 = abc_29733_new_n7934
* NET  3757 = abc_29733_new_n7933
* NET  3758 = abc_29733_new_n7931
* NET  3759 = abc_29733_new_n7930
* NET  3760 = abc_29733_new_n7929
* NET  3761 = abc_29733_new_n7927
* NET  3762 = abc_29733_new_n7926
* NET  3763 = abc_29733_new_n7925
* NET  3764 = abc_29733_new_n7892
* NET  3765 = abc_29733_new_n7891
* NET  3766 = abc_29733_new_n7890
* NET  3767 = abc_29733_new_n7857
* NET  3768 = abc_29733_new_n7856
* NET  3769 = abc_29733_new_n7855
* NET  3770 = abc_29733_new_n7822
* NET  3771 = abc_29733_new_n7821
* NET  3772 = abc_29733_new_n7788
* NET  3773 = abc_29733_new_n7787
* NET  3774 = abc_29733_new_n7754
* NET  3775 = abc_29733_new_n7753
* NET  3776 = abc_29733_new_n7720
* NET  3777 = abc_29733_new_n7719
* NET  3778 = abc_29733_new_n7686
* NET  3779 = abc_29733_new_n7685
* NET  3780 = abc_29733_new_n7684
* NET  3781 = abc_29733_new_n7651
* NET  3782 = abc_29733_new_n7650
* NET  3783 = abc_29733_new_n7649
* NET  3784 = abc_29733_new_n7648
* NET  3785 = abc_29733_new_n7615
* NET  3786 = abc_29733_new_n7614
* NET  3787 = abc_29733_new_n7613
* NET  3788 = abc_29733_new_n7580
* NET  3789 = abc_29733_new_n7579
* NET  3790 = abc_29733_new_n7578
* NET  3791 = abc_29733_new_n7545
* NET  3792 = abc_29733_new_n7544
* NET  3793 = abc_29733_new_n7543
* NET  3794 = abc_29733_new_n7510
* NET  3795 = abc_29733_new_n7509
* NET  3796 = abc_29733_new_n7508
* NET  3797 = abc_29733_new_n7506
* NET  3798 = abc_29733_new_n7505
* NET  3799 = abc_29733_new_n7503
* NET  3800 = abc_29733_new_n7502
* NET  3801 = abc_29733_new_n7501
* NET  3802 = abc_29733_new_n7499
* NET  3803 = abc_29733_new_n7498
* NET  3804 = abc_29733_new_n7497
* NET  3805 = abc_29733_new_n7495
* NET  3806 = abc_29733_new_n7494
* NET  3807 = abc_29733_new_n7493
* NET  3808 = abc_29733_new_n7491
* NET  3809 = abc_29733_new_n7490
* NET  3810 = abc_29733_new_n7489
* NET  3811 = abc_29733_new_n7487
* NET  3812 = abc_29733_new_n7486
* NET  3813 = abc_29733_new_n7485
* NET  3814 = abc_29733_new_n7483
* NET  3815 = abc_29733_new_n7482
* NET  3816 = abc_29733_new_n7481
* NET  3817 = abc_29733_new_n7479
* NET  3818 = abc_29733_new_n7478
* NET  3819 = abc_29733_new_n7477
* NET  3820 = abc_29733_new_n7475
* NET  3821 = abc_29733_new_n7474
* NET  3822 = abc_29733_new_n7473
* NET  3823 = abc_29733_new_n7471
* NET  3824 = abc_29733_new_n7470
* NET  3825 = abc_29733_new_n7469
* NET  3826 = abc_29733_new_n7467
* NET  3827 = abc_29733_new_n7466
* NET  3828 = abc_29733_new_n7465
* NET  3829 = abc_29733_new_n7463
* NET  3830 = abc_29733_new_n7462
* NET  3831 = abc_29733_new_n7461
* NET  3832 = abc_29733_new_n7459
* NET  3833 = abc_29733_new_n7458
* NET  3834 = abc_29733_new_n7457
* NET  3835 = abc_29733_new_n7455
* NET  3836 = abc_29733_new_n7454
* NET  3837 = abc_29733_new_n7453
* NET  3838 = abc_29733_new_n7451
* NET  3839 = abc_29733_new_n7450
* NET  3840 = abc_29733_new_n7449
* NET  3841 = abc_29733_new_n7447
* NET  3842 = abc_29733_new_n7446
* NET  3843 = abc_29733_new_n7445
* NET  3844 = abc_29733_new_n7443
* NET  3845 = abc_29733_new_n7442
* NET  3846 = abc_29733_new_n7441
* NET  3847 = abc_29733_new_n7439
* NET  3848 = abc_29733_new_n7438
* NET  3849 = abc_29733_new_n7437
* NET  3850 = abc_29733_new_n7435
* NET  3851 = abc_29733_new_n7434
* NET  3852 = abc_29733_new_n7433
* NET  3853 = abc_29733_new_n7431
* NET  3854 = abc_29733_new_n7430
* NET  3855 = abc_29733_new_n7429
* NET  3856 = abc_29733_new_n7427
* NET  3857 = abc_29733_new_n7426
* NET  3858 = abc_29733_new_n7425
* NET  3859 = abc_29733_new_n7423
* NET  3860 = abc_29733_new_n7422
* NET  3861 = abc_29733_new_n7421
* NET  3862 = abc_29733_new_n7419
* NET  3863 = abc_29733_new_n7418
* NET  3864 = abc_29733_new_n7417
* NET  3865 = abc_29733_new_n7416
* NET  3866 = abc_29733_new_n7414
* NET  3867 = abc_29733_new_n7413
* NET  3868 = abc_29733_new_n7412
* NET  3869 = abc_29733_new_n7411
* NET  3870 = abc_29733_new_n7409
* NET  3871 = abc_29733_new_n7408
* NET  3872 = abc_29733_new_n7407
* NET  3873 = abc_29733_new_n7406
* NET  3874 = abc_29733_new_n7404
* NET  3875 = abc_29733_new_n7403
* NET  3876 = abc_29733_new_n7402
* NET  3877 = abc_29733_new_n7401
* NET  3878 = abc_29733_new_n7399
* NET  3879 = abc_29733_new_n7398
* NET  3880 = abc_29733_new_n7397
* NET  3881 = abc_29733_new_n7396
* NET  3882 = abc_29733_new_n7394
* NET  3883 = abc_29733_new_n7393
* NET  3884 = abc_29733_new_n7392
* NET  3885 = abc_29733_new_n7391
* NET  3886 = abc_29733_new_n7389
* NET  3887 = abc_29733_new_n7388
* NET  3888 = abc_29733_new_n7387
* NET  3889 = abc_29733_new_n7386
* NET  3890 = abc_29733_new_n7384
* NET  3891 = abc_29733_new_n7383
* NET  3892 = abc_29733_new_n7381
* NET  3893 = abc_29733_new_n7380
* NET  3894 = abc_29733_new_n7378
* NET  3895 = abc_29733_new_n7377
* NET  3896 = abc_29733_new_n7376
* NET  3897 = abc_29733_new_n7375
* NET  3898 = abc_29733_new_n7374
* NET  3899 = abc_29733_new_n7373
* NET  3900 = abc_29733_new_n7372
* NET  3901 = abc_29733_new_n7371
* NET  3902 = abc_29733_new_n7370
* NET  3903 = abc_29733_new_n7369
* NET  3904 = abc_29733_new_n7368
* NET  3905 = abc_29733_new_n7367
* NET  3906 = abc_29733_new_n7366
* NET  3907 = abc_29733_new_n7365
* NET  3908 = abc_29733_new_n7363
* NET  3909 = abc_29733_new_n7362
* NET  3910 = abc_29733_new_n7361
* NET  3911 = abc_29733_new_n7360
* NET  3912 = abc_29733_new_n7359
* NET  3913 = abc_29733_new_n7358
* NET  3914 = abc_29733_new_n7357
* NET  3915 = abc_29733_new_n7356
* NET  3916 = abc_29733_new_n7355
* NET  3917 = abc_29733_new_n7354
* NET  3918 = abc_29733_new_n7353
* NET  3919 = abc_29733_new_n7352
* NET  3920 = abc_29733_new_n7351
* NET  3921 = abc_29733_new_n7350
* NET  3922 = abc_29733_new_n7349
* NET  3923 = abc_29733_new_n7348
* NET  3924 = abc_29733_new_n7347
* NET  3925 = abc_29733_new_n7346
* NET  3926 = abc_29733_new_n7345
* NET  3927 = abc_29733_new_n7344
* NET  3928 = abc_29733_new_n7343
* NET  3929 = abc_29733_new_n7342
* NET  3930 = abc_29733_new_n7341
* NET  3931 = abc_29733_new_n7340
* NET  3932 = abc_29733_new_n7339
* NET  3933 = abc_29733_new_n7338
* NET  3934 = abc_29733_new_n7337
* NET  3935 = abc_29733_new_n7336
* NET  3936 = abc_29733_new_n7335
* NET  3937 = abc_29733_new_n7334
* NET  3938 = abc_29733_new_n7333
* NET  3939 = abc_29733_new_n7332
* NET  3940 = abc_29733_new_n7331
* NET  3941 = abc_29733_new_n7330
* NET  3942 = abc_29733_new_n7329
* NET  3943 = abc_29733_new_n7328
* NET  3944 = abc_29733_new_n7327
* NET  3945 = abc_29733_new_n7326
* NET  3946 = abc_29733_new_n7325
* NET  3947 = abc_29733_new_n7324
* NET  3948 = abc_29733_new_n7323
* NET  3949 = abc_29733_new_n7322
* NET  3950 = abc_29733_new_n7321
* NET  3951 = abc_29733_new_n7320
* NET  3952 = abc_29733_new_n7319
* NET  3953 = abc_29733_new_n7318
* NET  3954 = abc_29733_new_n7317
* NET  3955 = abc_29733_new_n7316
* NET  3956 = abc_29733_new_n7315
* NET  3957 = abc_29733_new_n7314
* NET  3958 = abc_29733_new_n7313
* NET  3959 = abc_29733_new_n7312
* NET  3960 = abc_29733_new_n7311
* NET  3961 = abc_29733_new_n7310
* NET  3962 = abc_29733_new_n7309
* NET  3963 = abc_29733_new_n7307
* NET  3964 = abc_29733_new_n7306
* NET  3965 = abc_29733_new_n7305
* NET  3966 = abc_29733_new_n7304
* NET  3967 = abc_29733_new_n7303
* NET  3968 = abc_29733_new_n7302
* NET  3969 = abc_29733_new_n7301
* NET  3970 = abc_29733_new_n7300
* NET  3971 = abc_29733_new_n7299
* NET  3972 = abc_29733_new_n7298
* NET  3973 = abc_29733_new_n7297
* NET  3974 = abc_29733_new_n7296
* NET  3975 = abc_29733_new_n7295
* NET  3976 = abc_29733_new_n7294
* NET  3977 = abc_29733_new_n7293
* NET  3978 = abc_29733_new_n7292
* NET  3979 = abc_29733_new_n7291
* NET  3980 = abc_29733_new_n7290
* NET  3981 = abc_29733_new_n7289
* NET  3982 = abc_29733_new_n7288
* NET  3983 = abc_29733_new_n7287
* NET  3984 = abc_29733_new_n7286
* NET  3985 = abc_29733_new_n7285
* NET  3986 = abc_29733_new_n7284
* NET  3987 = abc_29733_new_n7283
* NET  3988 = abc_29733_new_n7282
* NET  3989 = abc_29733_new_n7281
* NET  3990 = abc_29733_new_n7280
* NET  3991 = abc_29733_new_n7279
* NET  3992 = abc_29733_new_n7278
* NET  3993 = abc_29733_new_n7277
* NET  3994 = abc_29733_new_n7276
* NET  3995 = abc_29733_new_n7275
* NET  3996 = abc_29733_new_n7274
* NET  3997 = abc_29733_new_n7273
* NET  3998 = abc_29733_new_n7272
* NET  3999 = abc_29733_new_n7271
* NET  4000 = abc_29733_new_n7270
* NET  4001 = abc_29733_new_n7269
* NET  4002 = abc_29733_new_n7268
* NET  4003 = abc_29733_new_n7267
* NET  4004 = abc_29733_new_n7266
* NET  4005 = abc_29733_new_n7265
* NET  4006 = abc_29733_new_n7264
* NET  4007 = abc_29733_new_n7263
* NET  4008 = abc_29733_new_n7262
* NET  4009 = abc_29733_new_n7261
* NET  4010 = abc_29733_new_n7260
* NET  4011 = abc_29733_new_n7259
* NET  4012 = abc_29733_new_n7257
* NET  4013 = abc_29733_new_n7256
* NET  4014 = abc_29733_new_n7255
* NET  4015 = abc_29733_new_n7254
* NET  4016 = abc_29733_new_n7253
* NET  4017 = abc_29733_new_n7252
* NET  4018 = abc_29733_new_n7251
* NET  4019 = abc_29733_new_n7250
* NET  4020 = abc_29733_new_n7249
* NET  4021 = abc_29733_new_n7248
* NET  4022 = abc_29733_new_n7247
* NET  4023 = abc_29733_new_n7246
* NET  4024 = abc_29733_new_n7245
* NET  4025 = abc_29733_new_n7244
* NET  4026 = abc_29733_new_n7243
* NET  4027 = abc_29733_new_n7242
* NET  4028 = abc_29733_new_n7241
* NET  4029 = abc_29733_new_n7240
* NET  4030 = abc_29733_new_n7239
* NET  4031 = abc_29733_new_n7238
* NET  4032 = abc_29733_new_n7237
* NET  4033 = abc_29733_new_n7236
* NET  4034 = abc_29733_new_n7235
* NET  4035 = abc_29733_new_n7234
* NET  4036 = abc_29733_new_n7233
* NET  4037 = abc_29733_new_n7232
* NET  4038 = abc_29733_new_n7231
* NET  4039 = abc_29733_new_n7230
* NET  4040 = abc_29733_new_n7229
* NET  4041 = abc_29733_new_n7228
* NET  4042 = abc_29733_new_n7227
* NET  4043 = abc_29733_new_n7226
* NET  4044 = abc_29733_new_n7225
* NET  4045 = abc_29733_new_n7224
* NET  4046 = abc_29733_new_n7223
* NET  4047 = abc_29733_new_n7222
* NET  4048 = abc_29733_new_n7221
* NET  4049 = abc_29733_new_n7220
* NET  4050 = abc_29733_new_n7219
* NET  4051 = abc_29733_new_n7218
* NET  4052 = abc_29733_new_n7217
* NET  4053 = abc_29733_new_n7216
* NET  4054 = abc_29733_new_n7215
* NET  4055 = abc_29733_new_n7214
* NET  4056 = abc_29733_new_n7213
* NET  4057 = abc_29733_new_n7212
* NET  4058 = abc_29733_new_n7211
* NET  4059 = abc_29733_new_n7210
* NET  4060 = abc_29733_new_n7209
* NET  4061 = abc_29733_new_n7208
* NET  4062 = abc_29733_new_n7207
* NET  4063 = abc_29733_new_n7206
* NET  4064 = abc_29733_new_n7205
* NET  4065 = abc_29733_new_n7204
* NET  4066 = abc_29733_new_n7203
* NET  4067 = abc_29733_new_n7202
* NET  4068 = abc_29733_new_n7200
* NET  4069 = abc_29733_new_n7199
* NET  4070 = abc_29733_new_n7198
* NET  4071 = abc_29733_new_n7197
* NET  4072 = abc_29733_new_n7196
* NET  4073 = abc_29733_new_n7195
* NET  4074 = abc_29733_new_n7194
* NET  4075 = abc_29733_new_n7193
* NET  4076 = abc_29733_new_n7192
* NET  4077 = abc_29733_new_n7191
* NET  4078 = abc_29733_new_n7190
* NET  4079 = abc_29733_new_n7189
* NET  4080 = abc_29733_new_n7188
* NET  4081 = abc_29733_new_n7187
* NET  4082 = abc_29733_new_n7186
* NET  4083 = abc_29733_new_n7185
* NET  4084 = abc_29733_new_n7184
* NET  4085 = abc_29733_new_n7183
* NET  4086 = abc_29733_new_n7182
* NET  4087 = abc_29733_new_n7181
* NET  4088 = abc_29733_new_n7180
* NET  4089 = abc_29733_new_n7179
* NET  4090 = abc_29733_new_n7178
* NET  4091 = abc_29733_new_n7177
* NET  4092 = abc_29733_new_n7176
* NET  4093 = abc_29733_new_n7175
* NET  4094 = abc_29733_new_n7174
* NET  4095 = abc_29733_new_n7173
* NET  4096 = abc_29733_new_n7172
* NET  4097 = abc_29733_new_n7171
* NET  4098 = abc_29733_new_n7170
* NET  4099 = abc_29733_new_n7169
* NET  4100 = abc_29733_new_n7168
* NET  4101 = abc_29733_new_n7167
* NET  4102 = abc_29733_new_n7166
* NET  4103 = abc_29733_new_n7165
* NET  4104 = abc_29733_new_n7164
* NET  4105 = abc_29733_new_n7163
* NET  4106 = abc_29733_new_n7162
* NET  4107 = abc_29733_new_n7161
* NET  4108 = abc_29733_new_n7160
* NET  4109 = abc_29733_new_n7159
* NET  4110 = abc_29733_new_n7158
* NET  4111 = abc_29733_new_n7157
* NET  4112 = abc_29733_new_n7156
* NET  4113 = abc_29733_new_n7155
* NET  4114 = abc_29733_new_n7154
* NET  4115 = abc_29733_new_n7153
* NET  4116 = abc_29733_new_n7151
* NET  4117 = abc_29733_new_n7150
* NET  4118 = abc_29733_new_n7149
* NET  4119 = abc_29733_new_n7148
* NET  4120 = abc_29733_new_n7147
* NET  4121 = abc_29733_new_n7146
* NET  4122 = abc_29733_new_n7145
* NET  4123 = abc_29733_new_n7144
* NET  4124 = abc_29733_new_n7143
* NET  4125 = abc_29733_new_n7142
* NET  4126 = abc_29733_new_n7141
* NET  4127 = abc_29733_new_n7140
* NET  4128 = abc_29733_new_n7139
* NET  4129 = abc_29733_new_n7138
* NET  4130 = abc_29733_new_n7137
* NET  4131 = abc_29733_new_n7136
* NET  4132 = abc_29733_new_n7135
* NET  4133 = abc_29733_new_n7134
* NET  4134 = abc_29733_new_n7133
* NET  4135 = abc_29733_new_n7132
* NET  4136 = abc_29733_new_n7131
* NET  4137 = abc_29733_new_n7130
* NET  4138 = abc_29733_new_n7129
* NET  4139 = abc_29733_new_n7128
* NET  4140 = abc_29733_new_n7127
* NET  4141 = abc_29733_new_n7126
* NET  4142 = abc_29733_new_n7125
* NET  4143 = abc_29733_new_n7124
* NET  4144 = abc_29733_new_n7123
* NET  4145 = abc_29733_new_n7122
* NET  4146 = abc_29733_new_n7121
* NET  4147 = abc_29733_new_n7120
* NET  4148 = abc_29733_new_n7119
* NET  4149 = abc_29733_new_n7118
* NET  4150 = abc_29733_new_n7117
* NET  4151 = abc_29733_new_n7116
* NET  4152 = abc_29733_new_n7115
* NET  4153 = abc_29733_new_n7114
* NET  4154 = abc_29733_new_n7113
* NET  4155 = abc_29733_new_n7112
* NET  4156 = abc_29733_new_n7111
* NET  4157 = abc_29733_new_n7110
* NET  4158 = abc_29733_new_n7109
* NET  4159 = abc_29733_new_n7108
* NET  4160 = abc_29733_new_n7107
* NET  4161 = abc_29733_new_n7106
* NET  4162 = abc_29733_new_n7105
* NET  4163 = abc_29733_new_n7104
* NET  4164 = abc_29733_new_n7103
* NET  4165 = abc_29733_new_n7102
* NET  4166 = abc_29733_new_n7101
* NET  4167 = abc_29733_new_n7099
* NET  4168 = abc_29733_new_n7098
* NET  4169 = abc_29733_new_n7097
* NET  4170 = abc_29733_new_n7096
* NET  4171 = abc_29733_new_n7095
* NET  4172 = abc_29733_new_n7094
* NET  4173 = abc_29733_new_n7093
* NET  4174 = abc_29733_new_n7092
* NET  4175 = abc_29733_new_n7091
* NET  4176 = abc_29733_new_n7090
* NET  4177 = abc_29733_new_n7089
* NET  4178 = abc_29733_new_n7088
* NET  4179 = abc_29733_new_n7087
* NET  4180 = abc_29733_new_n7086
* NET  4181 = abc_29733_new_n7085
* NET  4182 = abc_29733_new_n7084
* NET  4183 = abc_29733_new_n7083
* NET  4184 = abc_29733_new_n7082
* NET  4185 = abc_29733_new_n7081
* NET  4186 = abc_29733_new_n7080
* NET  4187 = abc_29733_new_n7079
* NET  4188 = abc_29733_new_n7078
* NET  4189 = abc_29733_new_n7077
* NET  4190 = abc_29733_new_n7076
* NET  4191 = abc_29733_new_n7075
* NET  4192 = abc_29733_new_n7074
* NET  4193 = abc_29733_new_n7073
* NET  4194 = abc_29733_new_n7072
* NET  4195 = abc_29733_new_n7071
* NET  4196 = abc_29733_new_n7070
* NET  4197 = abc_29733_new_n7069
* NET  4198 = abc_29733_new_n7068
* NET  4199 = abc_29733_new_n7067
* NET  4200 = abc_29733_new_n7066
* NET  4201 = abc_29733_new_n7065
* NET  4202 = abc_29733_new_n7064
* NET  4203 = abc_29733_new_n7063
* NET  4204 = abc_29733_new_n7062
* NET  4205 = abc_29733_new_n7061
* NET  4206 = abc_29733_new_n7060
* NET  4207 = abc_29733_new_n7059
* NET  4208 = abc_29733_new_n7058
* NET  4209 = abc_29733_new_n7057
* NET  4210 = abc_29733_new_n7056
* NET  4211 = abc_29733_new_n7055
* NET  4212 = abc_29733_new_n7054
* NET  4213 = abc_29733_new_n7053
* NET  4214 = abc_29733_new_n7052
* NET  4215 = abc_29733_new_n7051
* NET  4216 = abc_29733_new_n7050
* NET  4217 = abc_29733_new_n7049
* NET  4218 = abc_29733_new_n7047
* NET  4219 = abc_29733_new_n7046
* NET  4220 = abc_29733_new_n7045
* NET  4221 = abc_29733_new_n7044
* NET  4222 = abc_29733_new_n7043
* NET  4223 = abc_29733_new_n7042
* NET  4224 = abc_29733_new_n7041
* NET  4225 = abc_29733_new_n7040
* NET  4226 = abc_29733_new_n7039
* NET  4227 = abc_29733_new_n7038
* NET  4228 = abc_29733_new_n7037
* NET  4229 = abc_29733_new_n7036
* NET  4230 = abc_29733_new_n7035
* NET  4231 = abc_29733_new_n7034
* NET  4232 = abc_29733_new_n7033
* NET  4233 = abc_29733_new_n7032
* NET  4234 = abc_29733_new_n7031
* NET  4235 = abc_29733_new_n7030
* NET  4236 = abc_29733_new_n7029
* NET  4237 = abc_29733_new_n7028
* NET  4238 = abc_29733_new_n7027
* NET  4239 = abc_29733_new_n7026
* NET  4240 = abc_29733_new_n7025
* NET  4241 = abc_29733_new_n7024
* NET  4242 = abc_29733_new_n7023
* NET  4243 = abc_29733_new_n7022
* NET  4244 = abc_29733_new_n7021
* NET  4245 = abc_29733_new_n7020
* NET  4246 = abc_29733_new_n7019
* NET  4247 = abc_29733_new_n7018
* NET  4248 = abc_29733_new_n7017
* NET  4249 = abc_29733_new_n7016
* NET  4250 = abc_29733_new_n7015
* NET  4251 = abc_29733_new_n7014
* NET  4252 = abc_29733_new_n7013
* NET  4253 = abc_29733_new_n7012
* NET  4254 = abc_29733_new_n7011
* NET  4255 = abc_29733_new_n7010
* NET  4256 = abc_29733_new_n7009
* NET  4257 = abc_29733_new_n7008
* NET  4258 = abc_29733_new_n7007
* NET  4259 = abc_29733_new_n7006
* NET  4260 = abc_29733_new_n7005
* NET  4261 = abc_29733_new_n7004
* NET  4262 = abc_29733_new_n7003
* NET  4263 = abc_29733_new_n7002
* NET  4264 = abc_29733_new_n7001
* NET  4265 = abc_29733_new_n7000
* NET  4266 = abc_29733_new_n6999
* NET  4267 = abc_29733_new_n6998
* NET  4268 = abc_29733_new_n6997
* NET  4269 = abc_29733_new_n6996
* NET  4270 = abc_29733_new_n6995
* NET  4271 = abc_29733_new_n6994
* NET  4272 = abc_29733_new_n6992
* NET  4273 = abc_29733_new_n6991
* NET  4274 = abc_29733_new_n6990
* NET  4275 = abc_29733_new_n6989
* NET  4276 = abc_29733_new_n6988
* NET  4277 = abc_29733_new_n6987
* NET  4278 = abc_29733_new_n6986
* NET  4279 = abc_29733_new_n6985
* NET  4280 = abc_29733_new_n6984
* NET  4281 = abc_29733_new_n6983
* NET  4282 = abc_29733_new_n6982
* NET  4283 = abc_29733_new_n6981
* NET  4284 = abc_29733_new_n6980
* NET  4285 = abc_29733_new_n6979
* NET  4286 = abc_29733_new_n6978
* NET  4287 = abc_29733_new_n6977
* NET  4288 = abc_29733_new_n6976
* NET  4289 = abc_29733_new_n6975
* NET  4290 = abc_29733_new_n6974
* NET  4291 = abc_29733_new_n6973
* NET  4292 = abc_29733_new_n6972
* NET  4293 = abc_29733_new_n6971
* NET  4294 = abc_29733_new_n6970
* NET  4295 = abc_29733_new_n6969
* NET  4296 = abc_29733_new_n6968
* NET  4297 = abc_29733_new_n6967
* NET  4298 = abc_29733_new_n6966
* NET  4299 = abc_29733_new_n6965
* NET  4300 = abc_29733_new_n6964
* NET  4301 = abc_29733_new_n6963
* NET  4302 = abc_29733_new_n6962
* NET  4303 = abc_29733_new_n6961
* NET  4304 = abc_29733_new_n6960
* NET  4305 = abc_29733_new_n6959
* NET  4306 = abc_29733_new_n6958
* NET  4307 = abc_29733_new_n6957
* NET  4308 = abc_29733_new_n6956
* NET  4309 = abc_29733_new_n6955
* NET  4310 = abc_29733_new_n6954
* NET  4311 = abc_29733_new_n6953
* NET  4312 = abc_29733_new_n6952
* NET  4313 = abc_29733_new_n6951
* NET  4314 = abc_29733_new_n6950
* NET  4315 = abc_29733_new_n6949
* NET  4316 = abc_29733_new_n6948
* NET  4317 = abc_29733_new_n6947
* NET  4318 = abc_29733_new_n6946
* NET  4319 = abc_29733_new_n6945
* NET  4320 = abc_29733_new_n6944
* NET  4321 = abc_29733_new_n6943
* NET  4322 = abc_29733_new_n6942
* NET  4323 = abc_29733_new_n6941
* NET  4324 = abc_29733_new_n6940
* NET  4325 = abc_29733_new_n6939
* NET  4326 = abc_29733_new_n6938
* NET  4327 = abc_29733_new_n6937
* NET  4328 = abc_29733_new_n6936
* NET  4329 = abc_29733_new_n6935
* NET  4330 = abc_29733_new_n6934
* NET  4331 = abc_29733_new_n6933
* NET  4332 = abc_29733_new_n6932
* NET  4333 = abc_29733_new_n6931
* NET  4334 = abc_29733_new_n6930
* NET  4335 = abc_29733_new_n6928
* NET  4336 = abc_29733_new_n6927
* NET  4337 = abc_29733_new_n6926
* NET  4338 = abc_29733_new_n6925
* NET  4339 = abc_29733_new_n6924
* NET  4340 = abc_29733_new_n6923
* NET  4341 = abc_29733_new_n6922
* NET  4342 = abc_29733_new_n6921
* NET  4343 = abc_29733_new_n6920
* NET  4344 = abc_29733_new_n6919
* NET  4345 = abc_29733_new_n6918
* NET  4346 = abc_29733_new_n6917
* NET  4347 = abc_29733_new_n6916
* NET  4348 = abc_29733_new_n6915
* NET  4349 = abc_29733_new_n6914
* NET  4350 = abc_29733_new_n6913
* NET  4351 = abc_29733_new_n6912
* NET  4352 = abc_29733_new_n6911
* NET  4353 = abc_29733_new_n6910
* NET  4354 = abc_29733_new_n6909
* NET  4355 = abc_29733_new_n6908
* NET  4356 = abc_29733_new_n6907
* NET  4357 = abc_29733_new_n6906
* NET  4358 = abc_29733_new_n6905
* NET  4359 = abc_29733_new_n6904
* NET  4360 = abc_29733_new_n6903
* NET  4361 = abc_29733_new_n6902
* NET  4362 = abc_29733_new_n6901
* NET  4363 = abc_29733_new_n6900
* NET  4364 = abc_29733_new_n6899
* NET  4365 = abc_29733_new_n6898
* NET  4366 = abc_29733_new_n6897
* NET  4367 = abc_29733_new_n6896
* NET  4368 = abc_29733_new_n6895
* NET  4369 = abc_29733_new_n6894
* NET  4370 = abc_29733_new_n6893
* NET  4371 = abc_29733_new_n6892
* NET  4372 = abc_29733_new_n6891
* NET  4373 = abc_29733_new_n6890
* NET  4374 = abc_29733_new_n6889
* NET  4375 = abc_29733_new_n6888
* NET  4376 = abc_29733_new_n6887
* NET  4377 = abc_29733_new_n6886
* NET  4378 = abc_29733_new_n6885
* NET  4379 = abc_29733_new_n6884
* NET  4380 = abc_29733_new_n6883
* NET  4381 = abc_29733_new_n6882
* NET  4382 = abc_29733_new_n6881
* NET  4383 = abc_29733_new_n6880
* NET  4384 = abc_29733_new_n6879
* NET  4385 = abc_29733_new_n6878
* NET  4386 = abc_29733_new_n6877
* NET  4387 = abc_29733_new_n6876
* NET  4388 = abc_29733_new_n6875
* NET  4389 = abc_29733_new_n6874
* NET  4390 = abc_29733_new_n6873
* NET  4391 = abc_29733_new_n6872
* NET  4392 = abc_29733_new_n6871
* NET  4393 = abc_29733_new_n6870
* NET  4394 = abc_29733_new_n6869
* NET  4395 = abc_29733_new_n6868
* NET  4396 = abc_29733_new_n6867
* NET  4397 = abc_29733_new_n6866
* NET  4398 = abc_29733_new_n6865
* NET  4399 = abc_29733_new_n6864
* NET  4400 = abc_29733_new_n6863
* NET  4401 = abc_29733_new_n6862
* NET  4402 = abc_29733_new_n6860
* NET  4403 = abc_29733_new_n6859
* NET  4404 = abc_29733_new_n6858
* NET  4405 = abc_29733_new_n6857
* NET  4406 = abc_29733_new_n6856
* NET  4407 = abc_29733_new_n6855
* NET  4408 = abc_29733_new_n6854
* NET  4409 = abc_29733_new_n6853
* NET  4410 = abc_29733_new_n6852
* NET  4411 = abc_29733_new_n6851
* NET  4412 = abc_29733_new_n6850
* NET  4413 = abc_29733_new_n6849
* NET  4414 = abc_29733_new_n6848
* NET  4415 = abc_29733_new_n6847
* NET  4416 = abc_29733_new_n6846
* NET  4417 = abc_29733_new_n6845
* NET  4418 = abc_29733_new_n6844
* NET  4419 = abc_29733_new_n6843
* NET  4420 = abc_29733_new_n6842
* NET  4421 = abc_29733_new_n6841
* NET  4422 = abc_29733_new_n6840
* NET  4423 = abc_29733_new_n6839
* NET  4424 = abc_29733_new_n6838
* NET  4425 = abc_29733_new_n6837
* NET  4426 = abc_29733_new_n6836
* NET  4427 = abc_29733_new_n6835
* NET  4428 = abc_29733_new_n6834
* NET  4429 = abc_29733_new_n6833
* NET  4430 = abc_29733_new_n6832
* NET  4431 = abc_29733_new_n6831
* NET  4432 = abc_29733_new_n6830
* NET  4433 = abc_29733_new_n6829
* NET  4434 = abc_29733_new_n6828
* NET  4435 = abc_29733_new_n6827
* NET  4436 = abc_29733_new_n6826
* NET  4437 = abc_29733_new_n6825
* NET  4438 = abc_29733_new_n6824
* NET  4439 = abc_29733_new_n6823
* NET  4440 = abc_29733_new_n6822
* NET  4441 = abc_29733_new_n6821
* NET  4442 = abc_29733_new_n6820
* NET  4443 = abc_29733_new_n6819
* NET  4444 = abc_29733_new_n6818
* NET  4445 = abc_29733_new_n6817
* NET  4446 = abc_29733_new_n6816
* NET  4447 = abc_29733_new_n6815
* NET  4448 = abc_29733_new_n6814
* NET  4449 = abc_29733_new_n6813
* NET  4450 = abc_29733_new_n6812
* NET  4451 = abc_29733_new_n6811
* NET  4452 = abc_29733_new_n6810
* NET  4453 = abc_29733_new_n6809
* NET  4454 = abc_29733_new_n6808
* NET  4455 = abc_29733_new_n6807
* NET  4456 = abc_29733_new_n6806
* NET  4457 = abc_29733_new_n6805
* NET  4458 = abc_29733_new_n6804
* NET  4459 = abc_29733_new_n6803
* NET  4460 = abc_29733_new_n6802
* NET  4461 = abc_29733_new_n6801
* NET  4462 = abc_29733_new_n6800
* NET  4463 = abc_29733_new_n6799
* NET  4464 = abc_29733_new_n6798
* NET  4465 = abc_29733_new_n6797
* NET  4466 = abc_29733_new_n6796
* NET  4467 = abc_29733_new_n6795
* NET  4468 = abc_29733_new_n6794
* NET  4469 = abc_29733_new_n6793
* NET  4470 = abc_29733_new_n6792
* NET  4471 = abc_29733_new_n6791
* NET  4472 = abc_29733_new_n6790
* NET  4473 = abc_29733_new_n6789
* NET  4474 = abc_29733_new_n6788
* NET  4475 = abc_29733_new_n6786
* NET  4476 = abc_29733_new_n6785
* NET  4477 = abc_29733_new_n6784
* NET  4478 = abc_29733_new_n6783
* NET  4479 = abc_29733_new_n6782
* NET  4480 = abc_29733_new_n6781
* NET  4481 = abc_29733_new_n6780
* NET  4482 = abc_29733_new_n6779
* NET  4483 = abc_29733_new_n6778
* NET  4484 = abc_29733_new_n6777
* NET  4485 = abc_29733_new_n6776
* NET  4486 = abc_29733_new_n6775
* NET  4487 = abc_29733_new_n6774
* NET  4488 = abc_29733_new_n6773
* NET  4489 = abc_29733_new_n6772
* NET  4490 = abc_29733_new_n6771
* NET  4491 = abc_29733_new_n6770
* NET  4492 = abc_29733_new_n6769
* NET  4493 = abc_29733_new_n6768
* NET  4494 = abc_29733_new_n6767
* NET  4495 = abc_29733_new_n6766
* NET  4496 = abc_29733_new_n6765
* NET  4497 = abc_29733_new_n6764
* NET  4498 = abc_29733_new_n6763
* NET  4499 = abc_29733_new_n6762
* NET  4500 = abc_29733_new_n6761
* NET  4501 = abc_29733_new_n6760
* NET  4502 = abc_29733_new_n6759
* NET  4503 = abc_29733_new_n6758
* NET  4504 = abc_29733_new_n6757
* NET  4505 = abc_29733_new_n6756
* NET  4506 = abc_29733_new_n6755
* NET  4507 = abc_29733_new_n6754
* NET  4508 = abc_29733_new_n6753
* NET  4509 = abc_29733_new_n6752
* NET  4510 = abc_29733_new_n6751
* NET  4511 = abc_29733_new_n6750
* NET  4512 = abc_29733_new_n6749
* NET  4513 = abc_29733_new_n6748
* NET  4514 = abc_29733_new_n6747
* NET  4515 = abc_29733_new_n6746
* NET  4516 = abc_29733_new_n6745
* NET  4517 = abc_29733_new_n6744
* NET  4518 = abc_29733_new_n6743
* NET  4519 = abc_29733_new_n6742
* NET  4520 = abc_29733_new_n6741
* NET  4521 = abc_29733_new_n6740
* NET  4522 = abc_29733_new_n6739
* NET  4523 = abc_29733_new_n6738
* NET  4524 = abc_29733_new_n6737
* NET  4525 = abc_29733_new_n6735
* NET  4526 = abc_29733_new_n6734
* NET  4527 = abc_29733_new_n6733
* NET  4528 = abc_29733_new_n6732
* NET  4529 = abc_29733_new_n6731
* NET  4530 = abc_29733_new_n6730
* NET  4531 = abc_29733_new_n6729
* NET  4532 = abc_29733_new_n6728
* NET  4533 = abc_29733_new_n6727
* NET  4534 = abc_29733_new_n6726
* NET  4535 = abc_29733_new_n6725
* NET  4536 = abc_29733_new_n6724
* NET  4537 = abc_29733_new_n6723
* NET  4538 = abc_29733_new_n6722
* NET  4539 = abc_29733_new_n6721
* NET  4540 = abc_29733_new_n6720
* NET  4541 = abc_29733_new_n6719
* NET  4542 = abc_29733_new_n6718
* NET  4543 = abc_29733_new_n6717
* NET  4544 = abc_29733_new_n6716
* NET  4545 = abc_29733_new_n6715
* NET  4546 = abc_29733_new_n6714
* NET  4547 = abc_29733_new_n6713
* NET  4548 = abc_29733_new_n6712
* NET  4549 = abc_29733_new_n6711
* NET  4550 = abc_29733_new_n6710
* NET  4551 = abc_29733_new_n6709
* NET  4552 = abc_29733_new_n6708
* NET  4553 = abc_29733_new_n6707
* NET  4554 = abc_29733_new_n6706
* NET  4555 = abc_29733_new_n6705
* NET  4556 = abc_29733_new_n6704
* NET  4557 = abc_29733_new_n6703
* NET  4558 = abc_29733_new_n6702
* NET  4559 = abc_29733_new_n6701
* NET  4560 = abc_29733_new_n6700
* NET  4561 = abc_29733_new_n6699
* NET  4562 = abc_29733_new_n6698
* NET  4563 = abc_29733_new_n6697
* NET  4564 = abc_29733_new_n6696
* NET  4565 = abc_29733_new_n6695
* NET  4566 = abc_29733_new_n6694
* NET  4567 = abc_29733_new_n6693
* NET  4568 = abc_29733_new_n6692
* NET  4569 = abc_29733_new_n6690
* NET  4570 = abc_29733_new_n6689
* NET  4571 = abc_29733_new_n6688
* NET  4572 = abc_29733_new_n6687
* NET  4573 = abc_29733_new_n6686
* NET  4574 = abc_29733_new_n6685
* NET  4575 = abc_29733_new_n6684
* NET  4576 = abc_29733_new_n6683
* NET  4577 = abc_29733_new_n6682
* NET  4578 = abc_29733_new_n6681
* NET  4579 = abc_29733_new_n6680
* NET  4580 = abc_29733_new_n6679
* NET  4581 = abc_29733_new_n6678
* NET  4582 = abc_29733_new_n6677
* NET  4583 = abc_29733_new_n6676
* NET  4584 = abc_29733_new_n6675
* NET  4585 = abc_29733_new_n6674
* NET  4586 = abc_29733_new_n6673
* NET  4587 = abc_29733_new_n6672
* NET  4588 = abc_29733_new_n6671
* NET  4589 = abc_29733_new_n6670
* NET  4590 = abc_29733_new_n6669
* NET  4591 = abc_29733_new_n6668
* NET  4592 = abc_29733_new_n6667
* NET  4593 = abc_29733_new_n6666
* NET  4594 = abc_29733_new_n6665
* NET  4595 = abc_29733_new_n6664
* NET  4596 = abc_29733_new_n6663
* NET  4597 = abc_29733_new_n6662
* NET  4598 = abc_29733_new_n6661
* NET  4599 = abc_29733_new_n6660
* NET  4600 = abc_29733_new_n6659
* NET  4601 = abc_29733_new_n6658
* NET  4602 = abc_29733_new_n6657
* NET  4603 = abc_29733_new_n6656
* NET  4604 = abc_29733_new_n6655
* NET  4605 = abc_29733_new_n6654
* NET  4606 = abc_29733_new_n6653
* NET  4607 = abc_29733_new_n6652
* NET  4608 = abc_29733_new_n6651
* NET  4609 = abc_29733_new_n6650
* NET  4610 = abc_29733_new_n6649
* NET  4611 = abc_29733_new_n6648
* NET  4612 = abc_29733_new_n6647
* NET  4613 = abc_29733_new_n6646
* NET  4614 = abc_29733_new_n6645
* NET  4615 = abc_29733_new_n6644
* NET  4616 = abc_29733_new_n6643
* NET  4617 = abc_29733_new_n6642
* NET  4618 = abc_29733_new_n6641
* NET  4619 = abc_29733_new_n6640
* NET  4620 = abc_29733_new_n6639
* NET  4621 = abc_29733_new_n6638
* NET  4622 = abc_29733_new_n6637
* NET  4623 = abc_29733_new_n6636
* NET  4624 = abc_29733_new_n6635
* NET  4625 = abc_29733_new_n6634
* NET  4626 = abc_29733_new_n6633
* NET  4627 = abc_29733_new_n6632
* NET  4628 = abc_29733_new_n6631
* NET  4629 = abc_29733_new_n6630
* NET  4630 = abc_29733_new_n6629
* NET  4631 = abc_29733_new_n6628
* NET  4632 = abc_29733_new_n6627
* NET  4633 = abc_29733_new_n6626
* NET  4634 = abc_29733_new_n6624
* NET  4635 = abc_29733_new_n6623
* NET  4636 = abc_29733_new_n6622
* NET  4637 = abc_29733_new_n6621
* NET  4638 = abc_29733_new_n6620
* NET  4639 = abc_29733_new_n6619
* NET  4640 = abc_29733_new_n6618
* NET  4641 = abc_29733_new_n6617
* NET  4642 = abc_29733_new_n6616
* NET  4643 = abc_29733_new_n6615
* NET  4644 = abc_29733_new_n6614
* NET  4645 = abc_29733_new_n6613
* NET  4646 = abc_29733_new_n6612
* NET  4647 = abc_29733_new_n6611
* NET  4648 = abc_29733_new_n6610
* NET  4649 = abc_29733_new_n6609
* NET  4650 = abc_29733_new_n6608
* NET  4651 = abc_29733_new_n6607
* NET  4652 = abc_29733_new_n6606
* NET  4653 = abc_29733_new_n6605
* NET  4654 = abc_29733_new_n6604
* NET  4655 = abc_29733_new_n6603
* NET  4656 = abc_29733_new_n6602
* NET  4657 = abc_29733_new_n6601
* NET  4658 = abc_29733_new_n6600
* NET  4659 = abc_29733_new_n6599
* NET  4660 = abc_29733_new_n6598
* NET  4661 = abc_29733_new_n6597
* NET  4662 = abc_29733_new_n6596
* NET  4663 = abc_29733_new_n6595
* NET  4664 = abc_29733_new_n6594
* NET  4665 = abc_29733_new_n6593
* NET  4666 = abc_29733_new_n6592
* NET  4667 = abc_29733_new_n6591
* NET  4668 = abc_29733_new_n6590
* NET  4669 = abc_29733_new_n6589
* NET  4670 = abc_29733_new_n6588
* NET  4671 = abc_29733_new_n6587
* NET  4672 = abc_29733_new_n6586
* NET  4673 = abc_29733_new_n6585
* NET  4674 = abc_29733_new_n6584
* NET  4675 = abc_29733_new_n6583
* NET  4676 = abc_29733_new_n6582
* NET  4677 = abc_29733_new_n6581
* NET  4678 = abc_29733_new_n6580
* NET  4679 = abc_29733_new_n6579
* NET  4680 = abc_29733_new_n6578
* NET  4681 = abc_29733_new_n6576
* NET  4682 = abc_29733_new_n6575
* NET  4683 = abc_29733_new_n6574
* NET  4684 = abc_29733_new_n6573
* NET  4685 = abc_29733_new_n6572
* NET  4686 = abc_29733_new_n6571
* NET  4687 = abc_29733_new_n6570
* NET  4688 = abc_29733_new_n6569
* NET  4689 = abc_29733_new_n6568
* NET  4690 = abc_29733_new_n6567
* NET  4691 = abc_29733_new_n6566
* NET  4692 = abc_29733_new_n6565
* NET  4693 = abc_29733_new_n6564
* NET  4694 = abc_29733_new_n6563
* NET  4695 = abc_29733_new_n6562
* NET  4696 = abc_29733_new_n6561
* NET  4697 = abc_29733_new_n6560
* NET  4698 = abc_29733_new_n6559
* NET  4699 = abc_29733_new_n6558
* NET  4700 = abc_29733_new_n6557
* NET  4701 = abc_29733_new_n6556
* NET  4702 = abc_29733_new_n6555
* NET  4703 = abc_29733_new_n6554
* NET  4704 = abc_29733_new_n6553
* NET  4705 = abc_29733_new_n6552
* NET  4706 = abc_29733_new_n6551
* NET  4707 = abc_29733_new_n6550
* NET  4708 = abc_29733_new_n6549
* NET  4709 = abc_29733_new_n6548
* NET  4710 = abc_29733_new_n6547
* NET  4711 = abc_29733_new_n6546
* NET  4712 = abc_29733_new_n6545
* NET  4713 = abc_29733_new_n6544
* NET  4714 = abc_29733_new_n6543
* NET  4715 = abc_29733_new_n6542
* NET  4716 = abc_29733_new_n6541
* NET  4717 = abc_29733_new_n6540
* NET  4718 = abc_29733_new_n6539
* NET  4719 = abc_29733_new_n6538
* NET  4720 = abc_29733_new_n6537
* NET  4721 = abc_29733_new_n6536
* NET  4722 = abc_29733_new_n6535
* NET  4723 = abc_29733_new_n6534
* NET  4724 = abc_29733_new_n6533
* NET  4725 = abc_29733_new_n6532
* NET  4726 = abc_29733_new_n6531
* NET  4727 = abc_29733_new_n6530
* NET  4728 = abc_29733_new_n6529
* NET  4729 = abc_29733_new_n6528
* NET  4730 = abc_29733_new_n6527
* NET  4731 = abc_29733_new_n6525
* NET  4732 = abc_29733_new_n6524
* NET  4733 = abc_29733_new_n6523
* NET  4734 = abc_29733_new_n6522
* NET  4735 = abc_29733_new_n6521
* NET  4736 = abc_29733_new_n6520
* NET  4737 = abc_29733_new_n6519
* NET  4738 = abc_29733_new_n6518
* NET  4739 = abc_29733_new_n6517
* NET  4740 = abc_29733_new_n6516
* NET  4741 = abc_29733_new_n6515
* NET  4742 = abc_29733_new_n6514
* NET  4743 = abc_29733_new_n6513
* NET  4744 = abc_29733_new_n6512
* NET  4745 = abc_29733_new_n6511
* NET  4746 = abc_29733_new_n6510
* NET  4747 = abc_29733_new_n6509
* NET  4748 = abc_29733_new_n6508
* NET  4749 = abc_29733_new_n6507
* NET  4750 = abc_29733_new_n6506
* NET  4751 = abc_29733_new_n6505
* NET  4752 = abc_29733_new_n6504
* NET  4753 = abc_29733_new_n6503
* NET  4754 = abc_29733_new_n6502
* NET  4755 = abc_29733_new_n6501
* NET  4756 = abc_29733_new_n6500
* NET  4757 = abc_29733_new_n6499
* NET  4758 = abc_29733_new_n6498
* NET  4759 = abc_29733_new_n6497
* NET  4760 = abc_29733_new_n6496
* NET  4761 = abc_29733_new_n6495
* NET  4762 = abc_29733_new_n6494
* NET  4763 = abc_29733_new_n6493
* NET  4764 = abc_29733_new_n6492
* NET  4765 = abc_29733_new_n6491
* NET  4766 = abc_29733_new_n6490
* NET  4767 = abc_29733_new_n6489
* NET  4768 = abc_29733_new_n6488
* NET  4769 = abc_29733_new_n6487
* NET  4770 = abc_29733_new_n6486
* NET  4771 = abc_29733_new_n6485
* NET  4772 = abc_29733_new_n6484
* NET  4773 = abc_29733_new_n6483
* NET  4774 = abc_29733_new_n6482
* NET  4775 = abc_29733_new_n6481
* NET  4776 = abc_29733_new_n6480
* NET  4777 = abc_29733_new_n6479
* NET  4778 = abc_29733_new_n6478
* NET  4779 = abc_29733_new_n6477
* NET  4780 = abc_29733_new_n6475
* NET  4781 = abc_29733_new_n6474
* NET  4782 = abc_29733_new_n6473
* NET  4783 = abc_29733_new_n6472
* NET  4784 = abc_29733_new_n6471
* NET  4785 = abc_29733_new_n6470
* NET  4786 = abc_29733_new_n6469
* NET  4787 = abc_29733_new_n6468
* NET  4788 = abc_29733_new_n6467
* NET  4789 = abc_29733_new_n6466
* NET  4790 = abc_29733_new_n6465
* NET  4791 = abc_29733_new_n6464
* NET  4792 = abc_29733_new_n6463
* NET  4793 = abc_29733_new_n6462
* NET  4794 = abc_29733_new_n6461
* NET  4795 = abc_29733_new_n6460
* NET  4796 = abc_29733_new_n6459
* NET  4797 = abc_29733_new_n6458
* NET  4798 = abc_29733_new_n6457
* NET  4799 = abc_29733_new_n6456
* NET  4800 = abc_29733_new_n6455
* NET  4801 = abc_29733_new_n6454
* NET  4802 = abc_29733_new_n6453
* NET  4803 = abc_29733_new_n6452
* NET  4804 = abc_29733_new_n6451
* NET  4805 = abc_29733_new_n6450
* NET  4806 = abc_29733_new_n6449
* NET  4807 = abc_29733_new_n6448
* NET  4808 = abc_29733_new_n6447
* NET  4809 = abc_29733_new_n6446
* NET  4810 = abc_29733_new_n6445
* NET  4811 = abc_29733_new_n6444
* NET  4812 = abc_29733_new_n6443
* NET  4813 = abc_29733_new_n6442
* NET  4814 = abc_29733_new_n6441
* NET  4815 = abc_29733_new_n6440
* NET  4816 = abc_29733_new_n6439
* NET  4817 = abc_29733_new_n6438
* NET  4818 = abc_29733_new_n6437
* NET  4819 = abc_29733_new_n6436
* NET  4820 = abc_29733_new_n6435
* NET  4821 = abc_29733_new_n6434
* NET  4822 = abc_29733_new_n6433
* NET  4823 = abc_29733_new_n6432
* NET  4824 = abc_29733_new_n6431
* NET  4825 = abc_29733_new_n6430
* NET  4826 = abc_29733_new_n6429
* NET  4827 = abc_29733_new_n6428
* NET  4828 = abc_29733_new_n6427
* NET  4829 = abc_29733_new_n6426
* NET  4830 = abc_29733_new_n6425
* NET  4831 = abc_29733_new_n6424
* NET  4832 = abc_29733_new_n6423
* NET  4833 = abc_29733_new_n6422
* NET  4834 = abc_29733_new_n6421
* NET  4835 = abc_29733_new_n6420
* NET  4836 = abc_29733_new_n6418
* NET  4837 = abc_29733_new_n6417
* NET  4838 = abc_29733_new_n6416
* NET  4839 = abc_29733_new_n6415
* NET  4840 = abc_29733_new_n6414
* NET  4841 = abc_29733_new_n6413
* NET  4842 = abc_29733_new_n6412
* NET  4843 = abc_29733_new_n6411
* NET  4844 = abc_29733_new_n6410
* NET  4845 = abc_29733_new_n6409
* NET  4846 = abc_29733_new_n6408
* NET  4847 = abc_29733_new_n6407
* NET  4848 = abc_29733_new_n6406
* NET  4849 = abc_29733_new_n6405
* NET  4850 = abc_29733_new_n6404
* NET  4851 = abc_29733_new_n6403
* NET  4852 = abc_29733_new_n6402
* NET  4853 = abc_29733_new_n6401
* NET  4854 = abc_29733_new_n6400
* NET  4855 = abc_29733_new_n6399
* NET  4856 = abc_29733_new_n6398
* NET  4857 = abc_29733_new_n6397
* NET  4858 = abc_29733_new_n6396
* NET  4859 = abc_29733_new_n6395
* NET  4860 = abc_29733_new_n6394
* NET  4861 = abc_29733_new_n6393
* NET  4862 = abc_29733_new_n6392
* NET  4863 = abc_29733_new_n6391
* NET  4864 = abc_29733_new_n6390
* NET  4865 = abc_29733_new_n6389
* NET  4866 = abc_29733_new_n6388
* NET  4867 = abc_29733_new_n6387
* NET  4868 = abc_29733_new_n6386
* NET  4869 = abc_29733_new_n6385
* NET  4870 = abc_29733_new_n6384
* NET  4871 = abc_29733_new_n6383
* NET  4872 = abc_29733_new_n6382
* NET  4873 = abc_29733_new_n6381
* NET  4874 = abc_29733_new_n6380
* NET  4875 = abc_29733_new_n6379
* NET  4876 = abc_29733_new_n6378
* NET  4877 = abc_29733_new_n6377
* NET  4878 = abc_29733_new_n6376
* NET  4879 = abc_29733_new_n6375
* NET  4880 = abc_29733_new_n6374
* NET  4881 = abc_29733_new_n6373
* NET  4882 = abc_29733_new_n6372
* NET  4883 = abc_29733_new_n6371
* NET  4884 = abc_29733_new_n6370
* NET  4885 = abc_29733_new_n6369
* NET  4886 = abc_29733_new_n6367
* NET  4887 = abc_29733_new_n6366
* NET  4888 = abc_29733_new_n6365
* NET  4889 = abc_29733_new_n6364
* NET  4890 = abc_29733_new_n6363
* NET  4891 = abc_29733_new_n6362
* NET  4892 = abc_29733_new_n6361
* NET  4893 = abc_29733_new_n6360
* NET  4894 = abc_29733_new_n6359
* NET  4895 = abc_29733_new_n6358
* NET  4896 = abc_29733_new_n6357
* NET  4897 = abc_29733_new_n6356
* NET  4898 = abc_29733_new_n6355
* NET  4899 = abc_29733_new_n6354
* NET  4900 = abc_29733_new_n6353
* NET  4901 = abc_29733_new_n6352
* NET  4902 = abc_29733_new_n6351
* NET  4903 = abc_29733_new_n6350
* NET  4904 = abc_29733_new_n6349
* NET  4905 = abc_29733_new_n6348
* NET  4906 = abc_29733_new_n6347
* NET  4907 = abc_29733_new_n6346
* NET  4908 = abc_29733_new_n6345
* NET  4909 = abc_29733_new_n6344
* NET  4910 = abc_29733_new_n6343
* NET  4911 = abc_29733_new_n6342
* NET  4912 = abc_29733_new_n6341
* NET  4913 = abc_29733_new_n6340
* NET  4914 = abc_29733_new_n6339
* NET  4915 = abc_29733_new_n6338
* NET  4916 = abc_29733_new_n6337
* NET  4917 = abc_29733_new_n6336
* NET  4918 = abc_29733_new_n6335
* NET  4919 = abc_29733_new_n6334
* NET  4920 = abc_29733_new_n6333
* NET  4921 = abc_29733_new_n6332
* NET  4922 = abc_29733_new_n6331
* NET  4923 = abc_29733_new_n6330
* NET  4924 = abc_29733_new_n6329
* NET  4925 = abc_29733_new_n6328
* NET  4926 = abc_29733_new_n6327
* NET  4927 = abc_29733_new_n6326
* NET  4928 = abc_29733_new_n6325
* NET  4929 = abc_29733_new_n6324
* NET  4930 = abc_29733_new_n6323
* NET  4931 = abc_29733_new_n6322
* NET  4932 = abc_29733_new_n6321
* NET  4933 = abc_29733_new_n6320
* NET  4934 = abc_29733_new_n6319
* NET  4935 = abc_29733_new_n6318
* NET  4936 = abc_29733_new_n6317
* NET  4937 = abc_29733_new_n6316
* NET  4938 = abc_29733_new_n6315
* NET  4939 = abc_29733_new_n6314
* NET  4940 = abc_29733_new_n6313
* NET  4941 = abc_29733_new_n6312
* NET  4942 = abc_29733_new_n6311
* NET  4943 = abc_29733_new_n6310
* NET  4944 = abc_29733_new_n6309
* NET  4945 = abc_29733_new_n6308
* NET  4946 = abc_29733_new_n6306
* NET  4947 = abc_29733_new_n6305
* NET  4948 = abc_29733_new_n6304
* NET  4949 = abc_29733_new_n6303
* NET  4950 = abc_29733_new_n6302
* NET  4951 = abc_29733_new_n6301
* NET  4952 = abc_29733_new_n6300
* NET  4953 = abc_29733_new_n6299
* NET  4954 = abc_29733_new_n6298
* NET  4955 = abc_29733_new_n6297
* NET  4956 = abc_29733_new_n6296
* NET  4957 = abc_29733_new_n6295
* NET  4958 = abc_29733_new_n6294
* NET  4959 = abc_29733_new_n6293
* NET  4960 = abc_29733_new_n6292
* NET  4961 = abc_29733_new_n6291
* NET  4962 = abc_29733_new_n6290
* NET  4963 = abc_29733_new_n6289
* NET  4964 = abc_29733_new_n6288
* NET  4965 = abc_29733_new_n6287
* NET  4966 = abc_29733_new_n6286
* NET  4967 = abc_29733_new_n6285
* NET  4968 = abc_29733_new_n6284
* NET  4969 = abc_29733_new_n6283
* NET  4970 = abc_29733_new_n6282
* NET  4971 = abc_29733_new_n6281
* NET  4972 = abc_29733_new_n6280
* NET  4973 = abc_29733_new_n6279
* NET  4974 = abc_29733_new_n6278
* NET  4975 = abc_29733_new_n6277
* NET  4976 = abc_29733_new_n6276
* NET  4977 = abc_29733_new_n6275
* NET  4978 = abc_29733_new_n6274
* NET  4979 = abc_29733_new_n6273
* NET  4980 = abc_29733_new_n6272
* NET  4981 = abc_29733_new_n6271
* NET  4982 = abc_29733_new_n6270
* NET  4983 = abc_29733_new_n6269
* NET  4984 = abc_29733_new_n6268
* NET  4985 = abc_29733_new_n6267
* NET  4986 = abc_29733_new_n6266
* NET  4987 = abc_29733_new_n6265
* NET  4988 = abc_29733_new_n6264
* NET  4989 = abc_29733_new_n6263
* NET  4990 = abc_29733_new_n6262
* NET  4991 = abc_29733_new_n6261
* NET  4992 = abc_29733_new_n6260
* NET  4993 = abc_29733_new_n6259
* NET  4994 = abc_29733_new_n6258
* NET  4995 = abc_29733_new_n6257
* NET  4996 = abc_29733_new_n6256
* NET  4997 = abc_29733_new_n6255
* NET  4998 = abc_29733_new_n6254
* NET  4999 = abc_29733_new_n6253
* NET  5000 = abc_29733_new_n6252
* NET  5001 = abc_29733_new_n6251
* NET  5002 = abc_29733_new_n6250
* NET  5003 = abc_29733_new_n6249
* NET  5004 = abc_29733_new_n6247
* NET  5005 = abc_29733_new_n6246
* NET  5006 = abc_29733_new_n6245
* NET  5007 = abc_29733_new_n6244
* NET  5008 = abc_29733_new_n6243
* NET  5009 = abc_29733_new_n6242
* NET  5010 = abc_29733_new_n6241
* NET  5011 = abc_29733_new_n6240
* NET  5012 = abc_29733_new_n6239
* NET  5013 = abc_29733_new_n6238
* NET  5014 = abc_29733_new_n6237
* NET  5015 = abc_29733_new_n6236
* NET  5016 = abc_29733_new_n6235
* NET  5017 = abc_29733_new_n6234
* NET  5018 = abc_29733_new_n6233
* NET  5019 = abc_29733_new_n6232
* NET  5020 = abc_29733_new_n6231
* NET  5021 = abc_29733_new_n6230
* NET  5022 = abc_29733_new_n6229
* NET  5023 = abc_29733_new_n6228
* NET  5024 = abc_29733_new_n6227
* NET  5025 = abc_29733_new_n6226
* NET  5026 = abc_29733_new_n6225
* NET  5027 = abc_29733_new_n6224
* NET  5028 = abc_29733_new_n6223
* NET  5029 = abc_29733_new_n6222
* NET  5030 = abc_29733_new_n6221
* NET  5031 = abc_29733_new_n6220
* NET  5032 = abc_29733_new_n6219
* NET  5033 = abc_29733_new_n6218
* NET  5034 = abc_29733_new_n6217
* NET  5035 = abc_29733_new_n6216
* NET  5036 = abc_29733_new_n6215
* NET  5037 = abc_29733_new_n6214
* NET  5038 = abc_29733_new_n6213
* NET  5039 = abc_29733_new_n6212
* NET  5040 = abc_29733_new_n6211
* NET  5041 = abc_29733_new_n6210
* NET  5042 = abc_29733_new_n6209
* NET  5043 = abc_29733_new_n6208
* NET  5044 = abc_29733_new_n6207
* NET  5045 = abc_29733_new_n6206
* NET  5046 = abc_29733_new_n6205
* NET  5047 = abc_29733_new_n6204
* NET  5048 = abc_29733_new_n6203
* NET  5049 = abc_29733_new_n6202
* NET  5050 = abc_29733_new_n6201
* NET  5051 = abc_29733_new_n6199
* NET  5052 = abc_29733_new_n6198
* NET  5053 = abc_29733_new_n6197
* NET  5054 = abc_29733_new_n6196
* NET  5055 = abc_29733_new_n6195
* NET  5056 = abc_29733_new_n6194
* NET  5057 = abc_29733_new_n6193
* NET  5058 = abc_29733_new_n6192
* NET  5059 = abc_29733_new_n6191
* NET  5060 = abc_29733_new_n6190
* NET  5061 = abc_29733_new_n6189
* NET  5062 = abc_29733_new_n6188
* NET  5063 = abc_29733_new_n6187
* NET  5064 = abc_29733_new_n6186
* NET  5065 = abc_29733_new_n6185
* NET  5066 = abc_29733_new_n6184
* NET  5067 = abc_29733_new_n6183
* NET  5068 = abc_29733_new_n6182
* NET  5069 = abc_29733_new_n6181
* NET  5070 = abc_29733_new_n6180
* NET  5071 = abc_29733_new_n6179
* NET  5072 = abc_29733_new_n6178
* NET  5073 = abc_29733_new_n6177
* NET  5074 = abc_29733_new_n6176
* NET  5075 = abc_29733_new_n6175
* NET  5076 = abc_29733_new_n6174
* NET  5077 = abc_29733_new_n6173
* NET  5078 = abc_29733_new_n6172
* NET  5079 = abc_29733_new_n6171
* NET  5080 = abc_29733_new_n6170
* NET  5081 = abc_29733_new_n6169
* NET  5082 = abc_29733_new_n6168
* NET  5083 = abc_29733_new_n6167
* NET  5084 = abc_29733_new_n6166
* NET  5085 = abc_29733_new_n6165
* NET  5086 = abc_29733_new_n6164
* NET  5087 = abc_29733_new_n6163
* NET  5088 = abc_29733_new_n6162
* NET  5089 = abc_29733_new_n6161
* NET  5090 = abc_29733_new_n6160
* NET  5091 = abc_29733_new_n6159
* NET  5092 = abc_29733_new_n6158
* NET  5093 = abc_29733_new_n6157
* NET  5094 = abc_29733_new_n6156
* NET  5095 = abc_29733_new_n6155
* NET  5096 = abc_29733_new_n6154
* NET  5097 = abc_29733_new_n6153
* NET  5098 = abc_29733_new_n6152
* NET  5099 = abc_29733_new_n6151
* NET  5100 = abc_29733_new_n6150
* NET  5101 = abc_29733_new_n6149
* NET  5102 = abc_29733_new_n6148
* NET  5103 = abc_29733_new_n6147
* NET  5104 = abc_29733_new_n6146
* NET  5105 = abc_29733_new_n6145
* NET  5106 = abc_29733_new_n6144
* NET  5107 = abc_29733_new_n6143
* NET  5108 = abc_29733_new_n6141
* NET  5109 = abc_29733_new_n6140
* NET  5110 = abc_29733_new_n6139
* NET  5111 = abc_29733_new_n6138
* NET  5112 = abc_29733_new_n6137
* NET  5113 = abc_29733_new_n6136
* NET  5114 = abc_29733_new_n6135
* NET  5115 = abc_29733_new_n6134
* NET  5116 = abc_29733_new_n6133
* NET  5117 = abc_29733_new_n6132
* NET  5118 = abc_29733_new_n6131
* NET  5119 = abc_29733_new_n6130
* NET  5120 = abc_29733_new_n6129
* NET  5121 = abc_29733_new_n6128
* NET  5122 = abc_29733_new_n6127
* NET  5123 = abc_29733_new_n6126
* NET  5124 = abc_29733_new_n6125
* NET  5125 = abc_29733_new_n6124
* NET  5126 = abc_29733_new_n6123
* NET  5127 = abc_29733_new_n6122
* NET  5128 = abc_29733_new_n6121
* NET  5129 = abc_29733_new_n6120
* NET  5130 = abc_29733_new_n6119
* NET  5131 = abc_29733_new_n6118
* NET  5132 = abc_29733_new_n6117
* NET  5133 = abc_29733_new_n6116
* NET  5134 = abc_29733_new_n6115
* NET  5135 = abc_29733_new_n6114
* NET  5136 = abc_29733_new_n6113
* NET  5137 = abc_29733_new_n6112
* NET  5138 = abc_29733_new_n6111
* NET  5139 = abc_29733_new_n6110
* NET  5140 = abc_29733_new_n6109
* NET  5141 = abc_29733_new_n6108
* NET  5142 = abc_29733_new_n6107
* NET  5143 = abc_29733_new_n6106
* NET  5144 = abc_29733_new_n6105
* NET  5145 = abc_29733_new_n6104
* NET  5146 = abc_29733_new_n6103
* NET  5147 = abc_29733_new_n6102
* NET  5148 = abc_29733_new_n6101
* NET  5149 = abc_29733_new_n6100
* NET  5150 = abc_29733_new_n6099
* NET  5151 = abc_29733_new_n6098
* NET  5152 = abc_29733_new_n6097
* NET  5153 = abc_29733_new_n6095
* NET  5154 = abc_29733_new_n6094
* NET  5155 = abc_29733_new_n6093
* NET  5156 = abc_29733_new_n6092
* NET  5157 = abc_29733_new_n6091
* NET  5158 = abc_29733_new_n6090
* NET  5159 = abc_29733_new_n6089
* NET  5160 = abc_29733_new_n6088
* NET  5161 = abc_29733_new_n6087
* NET  5162 = abc_29733_new_n6086
* NET  5163 = abc_29733_new_n6085
* NET  5164 = abc_29733_new_n6084
* NET  5165 = abc_29733_new_n6083
* NET  5166 = abc_29733_new_n6082
* NET  5167 = abc_29733_new_n6081
* NET  5168 = abc_29733_new_n6080
* NET  5169 = abc_29733_new_n6079
* NET  5170 = abc_29733_new_n6078
* NET  5171 = abc_29733_new_n6077
* NET  5172 = abc_29733_new_n6076
* NET  5173 = abc_29733_new_n6075
* NET  5174 = abc_29733_new_n6074
* NET  5175 = abc_29733_new_n6073
* NET  5176 = abc_29733_new_n6072
* NET  5177 = abc_29733_new_n6071
* NET  5178 = abc_29733_new_n6070
* NET  5179 = abc_29733_new_n6069
* NET  5180 = abc_29733_new_n6068
* NET  5181 = abc_29733_new_n6067
* NET  5182 = abc_29733_new_n6066
* NET  5183 = abc_29733_new_n6065
* NET  5184 = abc_29733_new_n6064
* NET  5185 = abc_29733_new_n6063
* NET  5186 = abc_29733_new_n6062
* NET  5187 = abc_29733_new_n6061
* NET  5188 = abc_29733_new_n6060
* NET  5189 = abc_29733_new_n6059
* NET  5190 = abc_29733_new_n6058
* NET  5191 = abc_29733_new_n6057
* NET  5192 = abc_29733_new_n6056
* NET  5193 = abc_29733_new_n6055
* NET  5194 = abc_29733_new_n6054
* NET  5195 = abc_29733_new_n6053
* NET  5196 = abc_29733_new_n6052
* NET  5197 = abc_29733_new_n6051
* NET  5198 = abc_29733_new_n6050
* NET  5199 = abc_29733_new_n6049
* NET  5200 = abc_29733_new_n6048
* NET  5201 = abc_29733_new_n6047
* NET  5202 = abc_29733_new_n6046
* NET  5203 = abc_29733_new_n6045
* NET  5204 = abc_29733_new_n6044
* NET  5205 = abc_29733_new_n6043
* NET  5206 = abc_29733_new_n6042
* NET  5207 = abc_29733_new_n6040
* NET  5208 = abc_29733_new_n6039
* NET  5209 = abc_29733_new_n6038
* NET  5210 = abc_29733_new_n6037
* NET  5211 = abc_29733_new_n6036
* NET  5212 = abc_29733_new_n6035
* NET  5213 = abc_29733_new_n6034
* NET  5214 = abc_29733_new_n6033
* NET  5215 = abc_29733_new_n6032
* NET  5216 = abc_29733_new_n6031
* NET  5217 = abc_29733_new_n6030
* NET  5218 = abc_29733_new_n6029
* NET  5219 = abc_29733_new_n6028
* NET  5220 = abc_29733_new_n6027
* NET  5221 = abc_29733_new_n6026
* NET  5222 = abc_29733_new_n6025
* NET  5223 = abc_29733_new_n6024
* NET  5224 = abc_29733_new_n6023
* NET  5225 = abc_29733_new_n6022
* NET  5226 = abc_29733_new_n6021
* NET  5227 = abc_29733_new_n6020
* NET  5228 = abc_29733_new_n6019
* NET  5229 = abc_29733_new_n6018
* NET  5230 = abc_29733_new_n6017
* NET  5231 = abc_29733_new_n6016
* NET  5232 = abc_29733_new_n6015
* NET  5233 = abc_29733_new_n6014
* NET  5234 = abc_29733_new_n6013
* NET  5235 = abc_29733_new_n6012
* NET  5236 = abc_29733_new_n6011
* NET  5237 = abc_29733_new_n6010
* NET  5238 = abc_29733_new_n6009
* NET  5239 = abc_29733_new_n6008
* NET  5240 = abc_29733_new_n6007
* NET  5241 = abc_29733_new_n6006
* NET  5242 = abc_29733_new_n6005
* NET  5243 = abc_29733_new_n6004
* NET  5244 = abc_29733_new_n6003
* NET  5245 = abc_29733_new_n6002
* NET  5246 = abc_29733_new_n6001
* NET  5247 = abc_29733_new_n6000
* NET  5248 = abc_29733_new_n5999
* NET  5249 = abc_29733_new_n5998
* NET  5250 = abc_29733_new_n5997
* NET  5251 = abc_29733_new_n5996
* NET  5252 = abc_29733_new_n5995
* NET  5253 = abc_29733_new_n5994
* NET  5254 = abc_29733_new_n5993
* NET  5255 = abc_29733_new_n5992
* NET  5256 = abc_29733_new_n5991
* NET  5257 = abc_29733_new_n5990
* NET  5258 = abc_29733_new_n5989
* NET  5259 = abc_29733_new_n5988
* NET  5260 = abc_29733_new_n5986
* NET  5261 = abc_29733_new_n5985
* NET  5262 = abc_29733_new_n5984
* NET  5263 = abc_29733_new_n5983
* NET  5264 = abc_29733_new_n5982
* NET  5265 = abc_29733_new_n5981
* NET  5266 = abc_29733_new_n5980
* NET  5267 = abc_29733_new_n5979
* NET  5268 = abc_29733_new_n5978
* NET  5269 = abc_29733_new_n5977
* NET  5270 = abc_29733_new_n5976
* NET  5271 = abc_29733_new_n5975
* NET  5272 = abc_29733_new_n5974
* NET  5273 = abc_29733_new_n5973
* NET  5274 = abc_29733_new_n5972
* NET  5275 = abc_29733_new_n5971
* NET  5276 = abc_29733_new_n5970
* NET  5277 = abc_29733_new_n5969
* NET  5278 = abc_29733_new_n5968
* NET  5279 = abc_29733_new_n5967
* NET  5280 = abc_29733_new_n5966
* NET  5281 = abc_29733_new_n5965
* NET  5282 = abc_29733_new_n5964
* NET  5283 = abc_29733_new_n5963
* NET  5284 = abc_29733_new_n5962
* NET  5285 = abc_29733_new_n5961
* NET  5286 = abc_29733_new_n5960
* NET  5287 = abc_29733_new_n5959
* NET  5288 = abc_29733_new_n5958
* NET  5289 = abc_29733_new_n5957
* NET  5290 = abc_29733_new_n5956
* NET  5291 = abc_29733_new_n5955
* NET  5292 = abc_29733_new_n5954
* NET  5293 = abc_29733_new_n5953
* NET  5294 = abc_29733_new_n5952
* NET  5295 = abc_29733_new_n5951
* NET  5296 = abc_29733_new_n5950
* NET  5297 = abc_29733_new_n5949
* NET  5298 = abc_29733_new_n5948
* NET  5299 = abc_29733_new_n5947
* NET  5300 = abc_29733_new_n5946
* NET  5301 = abc_29733_new_n5945
* NET  5302 = abc_29733_new_n5944
* NET  5303 = abc_29733_new_n5943
* NET  5304 = abc_29733_new_n5942
* NET  5305 = abc_29733_new_n5941
* NET  5306 = abc_29733_new_n5940
* NET  5307 = abc_29733_new_n5939
* NET  5308 = abc_29733_new_n5938
* NET  5309 = abc_29733_new_n5937
* NET  5310 = abc_29733_new_n5936
* NET  5311 = abc_29733_new_n5934
* NET  5312 = abc_29733_new_n5933
* NET  5313 = abc_29733_new_n5932
* NET  5314 = abc_29733_new_n5931
* NET  5315 = abc_29733_new_n5930
* NET  5316 = abc_29733_new_n5929
* NET  5317 = abc_29733_new_n5928
* NET  5318 = abc_29733_new_n5927
* NET  5319 = abc_29733_new_n5926
* NET  5320 = abc_29733_new_n5925
* NET  5321 = abc_29733_new_n5924
* NET  5322 = abc_29733_new_n5923
* NET  5323 = abc_29733_new_n5922
* NET  5324 = abc_29733_new_n5921
* NET  5325 = abc_29733_new_n5920
* NET  5326 = abc_29733_new_n5919
* NET  5327 = abc_29733_new_n5918
* NET  5328 = abc_29733_new_n5917
* NET  5329 = abc_29733_new_n5916
* NET  5330 = abc_29733_new_n5915
* NET  5331 = abc_29733_new_n5914
* NET  5332 = abc_29733_new_n5913
* NET  5333 = abc_29733_new_n5912
* NET  5334 = abc_29733_new_n5911
* NET  5335 = abc_29733_new_n5910
* NET  5336 = abc_29733_new_n5909
* NET  5337 = abc_29733_new_n5908
* NET  5338 = abc_29733_new_n5907
* NET  5339 = abc_29733_new_n5906
* NET  5340 = abc_29733_new_n5905
* NET  5341 = abc_29733_new_n5904
* NET  5342 = abc_29733_new_n5903
* NET  5343 = abc_29733_new_n5902
* NET  5344 = abc_29733_new_n5901
* NET  5345 = abc_29733_new_n5900
* NET  5346 = abc_29733_new_n5899
* NET  5347 = abc_29733_new_n5898
* NET  5348 = abc_29733_new_n5897
* NET  5349 = abc_29733_new_n5896
* NET  5350 = abc_29733_new_n5895
* NET  5351 = abc_29733_new_n5894
* NET  5352 = abc_29733_new_n5893
* NET  5353 = abc_29733_new_n5892
* NET  5354 = abc_29733_new_n5891
* NET  5355 = abc_29733_new_n5890
* NET  5356 = abc_29733_new_n5889
* NET  5357 = abc_29733_new_n5888
* NET  5358 = abc_29733_new_n5887
* NET  5359 = abc_29733_new_n5886
* NET  5360 = abc_29733_new_n5885
* NET  5361 = abc_29733_new_n5884
* NET  5362 = abc_29733_new_n5882
* NET  5363 = abc_29733_new_n5881
* NET  5364 = abc_29733_new_n5880
* NET  5365 = abc_29733_new_n5879
* NET  5366 = abc_29733_new_n5878
* NET  5367 = abc_29733_new_n5877
* NET  5368 = abc_29733_new_n5876
* NET  5369 = abc_29733_new_n5875
* NET  5370 = abc_29733_new_n5874
* NET  5371 = abc_29733_new_n5873
* NET  5372 = abc_29733_new_n5872
* NET  5373 = abc_29733_new_n5871
* NET  5374 = abc_29733_new_n5870
* NET  5375 = abc_29733_new_n5869
* NET  5376 = abc_29733_new_n5868
* NET  5377 = abc_29733_new_n5867
* NET  5378 = abc_29733_new_n5866
* NET  5379 = abc_29733_new_n5865
* NET  5380 = abc_29733_new_n5864
* NET  5381 = abc_29733_new_n5863
* NET  5382 = abc_29733_new_n5862
* NET  5383 = abc_29733_new_n5861
* NET  5384 = abc_29733_new_n5860
* NET  5385 = abc_29733_new_n5859
* NET  5386 = abc_29733_new_n5858
* NET  5387 = abc_29733_new_n5857
* NET  5388 = abc_29733_new_n5856
* NET  5389 = abc_29733_new_n5855
* NET  5390 = abc_29733_new_n5854
* NET  5391 = abc_29733_new_n5853
* NET  5392 = abc_29733_new_n5852
* NET  5393 = abc_29733_new_n5851
* NET  5394 = abc_29733_new_n5850
* NET  5395 = abc_29733_new_n5849
* NET  5396 = abc_29733_new_n5848
* NET  5397 = abc_29733_new_n5847
* NET  5398 = abc_29733_new_n5846
* NET  5399 = abc_29733_new_n5845
* NET  5400 = abc_29733_new_n5844
* NET  5401 = abc_29733_new_n5843
* NET  5402 = abc_29733_new_n5842
* NET  5403 = abc_29733_new_n5841
* NET  5404 = abc_29733_new_n5840
* NET  5405 = abc_29733_new_n5839
* NET  5406 = abc_29733_new_n5838
* NET  5407 = abc_29733_new_n5837
* NET  5408 = abc_29733_new_n5836
* NET  5409 = abc_29733_new_n5834
* NET  5410 = abc_29733_new_n5833
* NET  5411 = abc_29733_new_n5832
* NET  5412 = abc_29733_new_n5831
* NET  5413 = abc_29733_new_n5830
* NET  5414 = abc_29733_new_n5829
* NET  5415 = abc_29733_new_n5828
* NET  5416 = abc_29733_new_n5827
* NET  5417 = abc_29733_new_n5826
* NET  5418 = abc_29733_new_n5825
* NET  5419 = abc_29733_new_n5824
* NET  5420 = abc_29733_new_n5823
* NET  5421 = abc_29733_new_n5822
* NET  5422 = abc_29733_new_n5821
* NET  5423 = abc_29733_new_n5820
* NET  5424 = abc_29733_new_n5819
* NET  5425 = abc_29733_new_n5818
* NET  5426 = abc_29733_new_n5817
* NET  5427 = abc_29733_new_n5816
* NET  5428 = abc_29733_new_n5815
* NET  5429 = abc_29733_new_n5814
* NET  5430 = abc_29733_new_n5813
* NET  5431 = abc_29733_new_n5812
* NET  5432 = abc_29733_new_n5811
* NET  5433 = abc_29733_new_n5810
* NET  5434 = abc_29733_new_n5809
* NET  5435 = abc_29733_new_n5808
* NET  5436 = abc_29733_new_n5807
* NET  5437 = abc_29733_new_n5806
* NET  5438 = abc_29733_new_n5805
* NET  5439 = abc_29733_new_n5804
* NET  5440 = abc_29733_new_n5803
* NET  5441 = abc_29733_new_n5802
* NET  5442 = abc_29733_new_n5801
* NET  5443 = abc_29733_new_n5800
* NET  5444 = abc_29733_new_n5799
* NET  5445 = abc_29733_new_n5798
* NET  5446 = abc_29733_new_n5797
* NET  5447 = abc_29733_new_n5796
* NET  5448 = abc_29733_new_n5795
* NET  5449 = abc_29733_new_n5794
* NET  5450 = abc_29733_new_n5793
* NET  5451 = abc_29733_new_n5792
* NET  5452 = abc_29733_new_n5791
* NET  5453 = abc_29733_new_n5790
* NET  5454 = abc_29733_new_n5789
* NET  5455 = abc_29733_new_n5788
* NET  5456 = abc_29733_new_n5787
* NET  5457 = abc_29733_new_n5786
* NET  5458 = abc_29733_new_n5785
* NET  5459 = abc_29733_new_n5784
* NET  5460 = abc_29733_new_n5783
* NET  5461 = abc_29733_new_n5782
* NET  5462 = abc_29733_new_n5781
* NET  5463 = abc_29733_new_n5780
* NET  5464 = abc_29733_new_n5779
* NET  5465 = abc_29733_new_n5778
* NET  5466 = abc_29733_new_n5777
* NET  5467 = abc_29733_new_n5776
* NET  5468 = abc_29733_new_n5775
* NET  5469 = abc_29733_new_n5774
* NET  5470 = abc_29733_new_n5773
* NET  5471 = abc_29733_new_n5772
* NET  5472 = abc_29733_new_n5771
* NET  5473 = abc_29733_new_n5770
* NET  5474 = abc_29733_new_n5769
* NET  5475 = abc_29733_new_n5767
* NET  5476 = abc_29733_new_n5766
* NET  5477 = abc_29733_new_n5765
* NET  5478 = abc_29733_new_n5764
* NET  5479 = abc_29733_new_n5763
* NET  5480 = abc_29733_new_n5762
* NET  5481 = abc_29733_new_n5761
* NET  5482 = abc_29733_new_n5760
* NET  5483 = abc_29733_new_n5759
* NET  5484 = abc_29733_new_n5758
* NET  5485 = abc_29733_new_n5757
* NET  5486 = abc_29733_new_n5756
* NET  5487 = abc_29733_new_n5755
* NET  5488 = abc_29733_new_n5754
* NET  5489 = abc_29733_new_n5753
* NET  5490 = abc_29733_new_n5752
* NET  5491 = abc_29733_new_n5751
* NET  5492 = abc_29733_new_n5750
* NET  5493 = abc_29733_new_n5749
* NET  5494 = abc_29733_new_n5748
* NET  5495 = abc_29733_new_n5747
* NET  5496 = abc_29733_new_n5746
* NET  5497 = abc_29733_new_n5745
* NET  5498 = abc_29733_new_n5744
* NET  5499 = abc_29733_new_n5743
* NET  5500 = abc_29733_new_n5742
* NET  5501 = abc_29733_new_n5741
* NET  5502 = abc_29733_new_n5740
* NET  5503 = abc_29733_new_n5739
* NET  5504 = abc_29733_new_n5738
* NET  5505 = abc_29733_new_n5737
* NET  5506 = abc_29733_new_n5736
* NET  5507 = abc_29733_new_n5735
* NET  5508 = abc_29733_new_n5734
* NET  5509 = abc_29733_new_n5733
* NET  5510 = abc_29733_new_n5732
* NET  5511 = abc_29733_new_n5731
* NET  5512 = abc_29733_new_n5730
* NET  5513 = abc_29733_new_n5729
* NET  5514 = abc_29733_new_n5728
* NET  5515 = abc_29733_new_n5727
* NET  5516 = abc_29733_new_n5726
* NET  5517 = abc_29733_new_n5725
* NET  5518 = abc_29733_new_n5724
* NET  5519 = abc_29733_new_n5723
* NET  5520 = abc_29733_new_n5722
* NET  5521 = abc_29733_new_n5721
* NET  5522 = abc_29733_new_n5720
* NET  5523 = abc_29733_new_n5719
* NET  5524 = abc_29733_new_n5718
* NET  5525 = abc_29733_new_n5717
* NET  5526 = abc_29733_new_n5716
* NET  5527 = abc_29733_new_n5715
* NET  5528 = abc_29733_new_n5714
* NET  5529 = abc_29733_new_n5713
* NET  5530 = abc_29733_new_n5712
* NET  5531 = abc_29733_new_n5711
* NET  5532 = abc_29733_new_n5710
* NET  5533 = abc_29733_new_n5709
* NET  5534 = abc_29733_new_n5707
* NET  5535 = abc_29733_new_n5706
* NET  5536 = abc_29733_new_n5705
* NET  5537 = abc_29733_new_n5704
* NET  5538 = abc_29733_new_n5703
* NET  5539 = abc_29733_new_n5702
* NET  5540 = abc_29733_new_n5701
* NET  5541 = abc_29733_new_n5700
* NET  5542 = abc_29733_new_n5699
* NET  5543 = abc_29733_new_n5698
* NET  5544 = abc_29733_new_n5697
* NET  5545 = abc_29733_new_n5696
* NET  5546 = abc_29733_new_n5695
* NET  5547 = abc_29733_new_n5694
* NET  5548 = abc_29733_new_n5693
* NET  5549 = abc_29733_new_n5692
* NET  5550 = abc_29733_new_n5691
* NET  5551 = abc_29733_new_n5690
* NET  5552 = abc_29733_new_n5689
* NET  5553 = abc_29733_new_n5688
* NET  5554 = abc_29733_new_n5687
* NET  5555 = abc_29733_new_n5686
* NET  5556 = abc_29733_new_n5685
* NET  5557 = abc_29733_new_n5684
* NET  5558 = abc_29733_new_n5683
* NET  5559 = abc_29733_new_n5682
* NET  5560 = abc_29733_new_n5681
* NET  5561 = abc_29733_new_n5680
* NET  5562 = abc_29733_new_n5679
* NET  5563 = abc_29733_new_n5678
* NET  5564 = abc_29733_new_n5677
* NET  5565 = abc_29733_new_n5676
* NET  5566 = abc_29733_new_n5675
* NET  5567 = abc_29733_new_n5674
* NET  5568 = abc_29733_new_n5673
* NET  5569 = abc_29733_new_n5672
* NET  5570 = abc_29733_new_n5671
* NET  5571 = abc_29733_new_n5670
* NET  5572 = abc_29733_new_n5669
* NET  5573 = abc_29733_new_n5668
* NET  5574 = abc_29733_new_n5667
* NET  5575 = abc_29733_new_n5666
* NET  5576 = abc_29733_new_n5665
* NET  5577 = abc_29733_new_n5664
* NET  5578 = abc_29733_new_n5663
* NET  5579 = abc_29733_new_n5662
* NET  5580 = abc_29733_new_n5661
* NET  5581 = abc_29733_new_n5660
* NET  5582 = abc_29733_new_n5659
* NET  5583 = abc_29733_new_n5658
* NET  5584 = abc_29733_new_n5657
* NET  5585 = abc_29733_new_n5656
* NET  5586 = abc_29733_new_n5655
* NET  5587 = abc_29733_new_n5654
* NET  5588 = abc_29733_new_n5653
* NET  5589 = abc_29733_new_n5652
* NET  5590 = abc_29733_new_n5651
* NET  5591 = abc_29733_new_n5650
* NET  5592 = abc_29733_new_n5649
* NET  5593 = abc_29733_new_n5648
* NET  5594 = abc_29733_new_n5647
* NET  5595 = abc_29733_new_n5646
* NET  5596 = abc_29733_new_n5645
* NET  5597 = abc_29733_new_n5644
* NET  5598 = abc_29733_new_n5643
* NET  5599 = abc_29733_new_n5642
* NET  5600 = abc_29733_new_n5641
* NET  5601 = abc_29733_new_n5640
* NET  5602 = abc_29733_new_n5639
* NET  5603 = abc_29733_new_n5638
* NET  5604 = abc_29733_new_n5637
* NET  5605 = abc_29733_new_n5636
* NET  5606 = abc_29733_new_n5635
* NET  5607 = abc_29733_new_n5634
* NET  5608 = abc_29733_new_n5633
* NET  5609 = abc_29733_new_n5632
* NET  5610 = abc_29733_new_n5630
* NET  5611 = abc_29733_new_n5629
* NET  5612 = abc_29733_new_n5628
* NET  5613 = abc_29733_new_n5627
* NET  5614 = abc_29733_new_n5626
* NET  5615 = abc_29733_new_n5625
* NET  5616 = abc_29733_new_n5624
* NET  5617 = abc_29733_new_n5623
* NET  5618 = abc_29733_new_n5622
* NET  5619 = abc_29733_new_n5621
* NET  5620 = abc_29733_new_n5620
* NET  5621 = abc_29733_new_n5619
* NET  5622 = abc_29733_new_n5618
* NET  5623 = abc_29733_new_n5617
* NET  5624 = abc_29733_new_n5616
* NET  5625 = abc_29733_new_n5615
* NET  5626 = abc_29733_new_n5614
* NET  5627 = abc_29733_new_n5613
* NET  5628 = abc_29733_new_n5612
* NET  5629 = abc_29733_new_n5611
* NET  5630 = abc_29733_new_n5610
* NET  5631 = abc_29733_new_n5609
* NET  5632 = abc_29733_new_n5608
* NET  5633 = abc_29733_new_n5607
* NET  5634 = abc_29733_new_n5606
* NET  5635 = abc_29733_new_n5605
* NET  5636 = abc_29733_new_n5604
* NET  5637 = abc_29733_new_n5603
* NET  5638 = abc_29733_new_n5602
* NET  5639 = abc_29733_new_n5601
* NET  5640 = abc_29733_new_n5600
* NET  5641 = abc_29733_new_n5599
* NET  5642 = abc_29733_new_n5598
* NET  5643 = abc_29733_new_n5597
* NET  5644 = abc_29733_new_n5596
* NET  5645 = abc_29733_new_n5595
* NET  5646 = abc_29733_new_n5594
* NET  5647 = abc_29733_new_n5593
* NET  5648 = abc_29733_new_n5592
* NET  5649 = abc_29733_new_n5591
* NET  5650 = abc_29733_new_n5590
* NET  5651 = abc_29733_new_n5589
* NET  5652 = abc_29733_new_n5588
* NET  5653 = abc_29733_new_n5587
* NET  5654 = abc_29733_new_n5586
* NET  5655 = abc_29733_new_n5585
* NET  5656 = abc_29733_new_n5584
* NET  5657 = abc_29733_new_n5582
* NET  5658 = abc_29733_new_n5581
* NET  5659 = abc_29733_new_n5580
* NET  5660 = abc_29733_new_n5579
* NET  5661 = abc_29733_new_n5578
* NET  5662 = abc_29733_new_n5577
* NET  5663 = abc_29733_new_n5576
* NET  5664 = abc_29733_new_n5575
* NET  5665 = abc_29733_new_n5574
* NET  5666 = abc_29733_new_n5573
* NET  5667 = abc_29733_new_n5572
* NET  5668 = abc_29733_new_n5571
* NET  5669 = abc_29733_new_n5570
* NET  5670 = abc_29733_new_n5569
* NET  5671 = abc_29733_new_n5568
* NET  5672 = abc_29733_new_n5567
* NET  5673 = abc_29733_new_n5566
* NET  5674 = abc_29733_new_n5565
* NET  5675 = abc_29733_new_n5564
* NET  5676 = abc_29733_new_n5563
* NET  5677 = abc_29733_new_n5562
* NET  5678 = abc_29733_new_n5561
* NET  5679 = abc_29733_new_n5560
* NET  5680 = abc_29733_new_n5559
* NET  5681 = abc_29733_new_n5558
* NET  5682 = abc_29733_new_n5557
* NET  5683 = abc_29733_new_n5556
* NET  5684 = abc_29733_new_n5555
* NET  5685 = abc_29733_new_n5554
* NET  5686 = abc_29733_new_n5553
* NET  5687 = abc_29733_new_n5552
* NET  5688 = abc_29733_new_n5551
* NET  5689 = abc_29733_new_n5550
* NET  5690 = abc_29733_new_n5549
* NET  5691 = abc_29733_new_n5548
* NET  5692 = abc_29733_new_n5547
* NET  5693 = abc_29733_new_n5546
* NET  5694 = abc_29733_new_n5545
* NET  5695 = abc_29733_new_n5544
* NET  5696 = abc_29733_new_n5542
* NET  5697 = abc_29733_new_n5541
* NET  5698 = abc_29733_new_n5540
* NET  5699 = abc_29733_new_n5539
* NET  5700 = abc_29733_new_n5538
* NET  5701 = abc_29733_new_n5537
* NET  5702 = abc_29733_new_n5536
* NET  5703 = abc_29733_new_n5535
* NET  5704 = abc_29733_new_n5534
* NET  5705 = abc_29733_new_n5533
* NET  5706 = abc_29733_new_n5532
* NET  5707 = abc_29733_new_n5531
* NET  5708 = abc_29733_new_n5530
* NET  5709 = abc_29733_new_n5529
* NET  5710 = abc_29733_new_n5528
* NET  5711 = abc_29733_new_n5527
* NET  5712 = abc_29733_new_n5526
* NET  5713 = abc_29733_new_n5525
* NET  5714 = abc_29733_new_n5524
* NET  5715 = abc_29733_new_n5523
* NET  5716 = abc_29733_new_n5522
* NET  5717 = abc_29733_new_n5521
* NET  5718 = abc_29733_new_n5520
* NET  5719 = abc_29733_new_n5519
* NET  5720 = abc_29733_new_n5518
* NET  5721 = abc_29733_new_n5517
* NET  5722 = abc_29733_new_n5516
* NET  5723 = abc_29733_new_n5515
* NET  5724 = abc_29733_new_n5514
* NET  5725 = abc_29733_new_n5513
* NET  5726 = abc_29733_new_n5512
* NET  5727 = abc_29733_new_n5511
* NET  5728 = abc_29733_new_n5510
* NET  5729 = abc_29733_new_n5509
* NET  5730 = abc_29733_new_n5508
* NET  5731 = abc_29733_new_n5507
* NET  5732 = abc_29733_new_n5506
* NET  5733 = abc_29733_new_n5505
* NET  5734 = abc_29733_new_n5504
* NET  5735 = abc_29733_new_n5503
* NET  5736 = abc_29733_new_n5502
* NET  5737 = abc_29733_new_n5501
* NET  5738 = abc_29733_new_n5500
* NET  5739 = abc_29733_new_n5499
* NET  5740 = abc_29733_new_n5498
* NET  5741 = abc_29733_new_n5497
* NET  5742 = abc_29733_new_n5496
* NET  5743 = abc_29733_new_n5495
* NET  5744 = abc_29733_new_n5494
* NET  5745 = abc_29733_new_n5493
* NET  5746 = abc_29733_new_n5492
* NET  5747 = abc_29733_new_n5491
* NET  5748 = abc_29733_new_n5490
* NET  5749 = abc_29733_new_n5488
* NET  5750 = abc_29733_new_n5487
* NET  5751 = abc_29733_new_n5486
* NET  5752 = abc_29733_new_n5465
* NET  5753 = abc_29733_new_n5434
* NET  5754 = abc_29733_new_n5433
* NET  5755 = abc_29733_new_n5431
* NET  5756 = abc_29733_new_n5429
* NET  5757 = abc_29733_new_n5427
* NET  5758 = abc_29733_new_n5425
* NET  5759 = abc_29733_new_n5423
* NET  5760 = abc_29733_new_n5421
* NET  5761 = abc_29733_new_n5419
* NET  5762 = abc_29733_new_n5417
* NET  5763 = abc_29733_new_n5407
* NET  5764 = abc_29733_new_n5406
* NET  5765 = abc_29733_new_n5405
* NET  5766 = abc_29733_new_n5404
* NET  5767 = abc_29733_new_n5402
* NET  5768 = abc_29733_new_n5401
* NET  5769 = abc_29733_new_n5400
* NET  5770 = abc_29733_new_n5399
* NET  5771 = abc_29733_new_n5397
* NET  5772 = abc_29733_new_n5396
* NET  5773 = abc_29733_new_n5395
* NET  5774 = abc_29733_new_n5394
* NET  5775 = abc_29733_new_n5392
* NET  5776 = abc_29733_new_n5391
* NET  5777 = abc_29733_new_n5390
* NET  5778 = abc_29733_new_n5389
* NET  5779 = abc_29733_new_n5387
* NET  5780 = abc_29733_new_n5386
* NET  5781 = abc_29733_new_n5385
* NET  5782 = abc_29733_new_n5384
* NET  5783 = abc_29733_new_n5382
* NET  5784 = abc_29733_new_n5381
* NET  5785 = abc_29733_new_n5380
* NET  5786 = abc_29733_new_n5379
* NET  5787 = abc_29733_new_n5377
* NET  5788 = abc_29733_new_n5376
* NET  5789 = abc_29733_new_n5375
* NET  5790 = abc_29733_new_n5374
* NET  5791 = abc_29733_new_n5372
* NET  5792 = abc_29733_new_n5371
* NET  5793 = abc_29733_new_n5370
* NET  5794 = abc_29733_new_n5369
* NET  5795 = abc_29733_new_n5367
* NET  5796 = abc_29733_new_n5366
* NET  5797 = abc_29733_new_n5364
* NET  5798 = abc_29733_new_n5363
* NET  5799 = abc_29733_new_n5361
* NET  5800 = abc_29733_new_n5360
* NET  5801 = abc_29733_new_n5358
* NET  5802 = abc_29733_new_n5357
* NET  5803 = abc_29733_new_n5356
* NET  5804 = abc_29733_new_n5355
* NET  5805 = abc_29733_new_n5354
* NET  5806 = abc_29733_new_n5353
* NET  5807 = abc_29733_new_n5352
* NET  5808 = abc_29733_new_n5351
* NET  5809 = abc_29733_new_n5350
* NET  5810 = abc_29733_new_n5349
* NET  5811 = abc_29733_new_n5348
* NET  5812 = abc_29733_new_n5346
* NET  5813 = abc_29733_new_n5345
* NET  5814 = abc_29733_new_n5344
* NET  5815 = abc_29733_new_n5343
* NET  5816 = abc_29733_new_n5342
* NET  5817 = abc_29733_new_n5341
* NET  5818 = abc_29733_new_n5340
* NET  5819 = abc_29733_new_n5339
* NET  5820 = abc_29733_new_n5338
* NET  5821 = abc_29733_new_n5336
* NET  5822 = abc_29733_new_n5335
* NET  5823 = abc_29733_new_n5334
* NET  5824 = abc_29733_new_n5333
* NET  5825 = abc_29733_new_n5332
* NET  5826 = abc_29733_new_n5331
* NET  5827 = abc_29733_new_n5330
* NET  5828 = abc_29733_new_n5329
* NET  5829 = abc_29733_new_n5328
* NET  5830 = abc_29733_new_n5326
* NET  5831 = abc_29733_new_n5325
* NET  5832 = abc_29733_new_n5324
* NET  5833 = abc_29733_new_n5323
* NET  5834 = abc_29733_new_n5322
* NET  5835 = abc_29733_new_n5321
* NET  5836 = abc_29733_new_n5320
* NET  5837 = abc_29733_new_n5319
* NET  5838 = abc_29733_new_n5318
* NET  5839 = abc_29733_new_n5317
* NET  5840 = abc_29733_new_n5316
* NET  5841 = abc_29733_new_n5314
* NET  5842 = abc_29733_new_n5313
* NET  5843 = abc_29733_new_n5312
* NET  5844 = abc_29733_new_n5311
* NET  5845 = abc_29733_new_n5310
* NET  5846 = abc_29733_new_n5309
* NET  5847 = abc_29733_new_n5308
* NET  5848 = abc_29733_new_n5307
* NET  5849 = abc_29733_new_n5306
* NET  5850 = abc_29733_new_n5305
* NET  5851 = abc_29733_new_n5304
* NET  5852 = abc_29733_new_n5303
* NET  5853 = abc_29733_new_n5301
* NET  5854 = abc_29733_new_n5300
* NET  5855 = abc_29733_new_n5299
* NET  5856 = abc_29733_new_n5298
* NET  5857 = abc_29733_new_n5297
* NET  5858 = abc_29733_new_n5296
* NET  5859 = abc_29733_new_n5295
* NET  5860 = abc_29733_new_n5294
* NET  5861 = abc_29733_new_n5293
* NET  5862 = abc_29733_new_n5292
* NET  5863 = abc_29733_new_n5291
* NET  5864 = abc_29733_new_n5290
* NET  5865 = abc_29733_new_n5288
* NET  5866 = abc_29733_new_n5287
* NET  5867 = abc_29733_new_n5286
* NET  5868 = abc_29733_new_n5285
* NET  5869 = abc_29733_new_n5284
* NET  5870 = abc_29733_new_n5283
* NET  5871 = abc_29733_new_n5282
* NET  5872 = abc_29733_new_n5281
* NET  5873 = abc_29733_new_n5280
* NET  5874 = abc_29733_new_n5279
* NET  5875 = abc_29733_new_n5278
* NET  5876 = abc_29733_new_n5276
* NET  5877 = abc_29733_new_n5275
* NET  5878 = abc_29733_new_n5274
* NET  5879 = abc_29733_new_n5273
* NET  5880 = abc_29733_new_n5272
* NET  5881 = abc_29733_new_n5271
* NET  5882 = abc_29733_new_n5270
* NET  5883 = abc_29733_new_n5269
* NET  5884 = abc_29733_new_n5268
* NET  5885 = abc_29733_new_n5267
* NET  5886 = abc_29733_new_n5266
* NET  5887 = abc_29733_new_n5265
* NET  5888 = abc_29733_new_n5263
* NET  5889 = abc_29733_new_n5262
* NET  5890 = abc_29733_new_n5261
* NET  5891 = abc_29733_new_n5260
* NET  5892 = abc_29733_new_n5259
* NET  5893 = abc_29733_new_n5258
* NET  5894 = abc_29733_new_n5257
* NET  5895 = abc_29733_new_n5256
* NET  5896 = abc_29733_new_n5255
* NET  5897 = abc_29733_new_n5254
* NET  5898 = abc_29733_new_n5252
* NET  5899 = abc_29733_new_n5251
* NET  5900 = abc_29733_new_n5250
* NET  5901 = abc_29733_new_n5249
* NET  5902 = abc_29733_new_n5248
* NET  5903 = abc_29733_new_n5247
* NET  5904 = abc_29733_new_n5246
* NET  5905 = abc_29733_new_n5245
* NET  5906 = abc_29733_new_n5244
* NET  5907 = abc_29733_new_n5243
* NET  5908 = abc_29733_new_n5242
* NET  5909 = abc_29733_new_n5241
* NET  5910 = abc_29733_new_n5239
* NET  5911 = abc_29733_new_n5238
* NET  5912 = abc_29733_new_n5237
* NET  5913 = abc_29733_new_n5236
* NET  5914 = abc_29733_new_n5235
* NET  5915 = abc_29733_new_n5234
* NET  5916 = abc_29733_new_n5233
* NET  5917 = abc_29733_new_n5232
* NET  5918 = abc_29733_new_n5231
* NET  5919 = abc_29733_new_n5230
* NET  5920 = abc_29733_new_n5229
* NET  5921 = abc_29733_new_n5227
* NET  5922 = abc_29733_new_n5226
* NET  5923 = abc_29733_new_n5225
* NET  5924 = abc_29733_new_n5224
* NET  5925 = abc_29733_new_n5223
* NET  5926 = abc_29733_new_n5222
* NET  5927 = abc_29733_new_n5221
* NET  5928 = abc_29733_new_n5220
* NET  5929 = abc_29733_new_n5219
* NET  5930 = abc_29733_new_n5218
* NET  5931 = abc_29733_new_n5216
* NET  5932 = abc_29733_new_n5215
* NET  5933 = abc_29733_new_n5214
* NET  5934 = abc_29733_new_n5213
* NET  5935 = abc_29733_new_n5212
* NET  5936 = abc_29733_new_n5211
* NET  5937 = abc_29733_new_n5210
* NET  5938 = abc_29733_new_n5209
* NET  5939 = abc_29733_new_n5208
* NET  5940 = abc_29733_new_n5207
* NET  5941 = abc_29733_new_n5205
* NET  5942 = abc_29733_new_n5204
* NET  5943 = abc_29733_new_n5203
* NET  5944 = abc_29733_new_n5202
* NET  5945 = abc_29733_new_n5201
* NET  5946 = abc_29733_new_n5200
* NET  5947 = abc_29733_new_n5199
* NET  5948 = abc_29733_new_n5198
* NET  5949 = abc_29733_new_n5197
* NET  5950 = abc_29733_new_n5196
* NET  5951 = abc_29733_new_n5195
* NET  5952 = abc_29733_new_n5194
* NET  5953 = abc_29733_new_n5192
* NET  5954 = abc_29733_new_n5191
* NET  5955 = abc_29733_new_n5190
* NET  5956 = abc_29733_new_n5189
* NET  5957 = abc_29733_new_n5188
* NET  5958 = abc_29733_new_n5187
* NET  5959 = abc_29733_new_n5186
* NET  5960 = abc_29733_new_n5185
* NET  5961 = abc_29733_new_n5184
* NET  5962 = abc_29733_new_n5183
* NET  5963 = abc_29733_new_n5181
* NET  5964 = abc_29733_new_n5180
* NET  5965 = abc_29733_new_n5179
* NET  5966 = abc_29733_new_n5178
* NET  5967 = abc_29733_new_n5177
* NET  5968 = abc_29733_new_n5176
* NET  5969 = abc_29733_new_n5175
* NET  5970 = abc_29733_new_n5174
* NET  5971 = abc_29733_new_n5172
* NET  5972 = abc_29733_new_n5171
* NET  5973 = abc_29733_new_n5170
* NET  5974 = abc_29733_new_n5169
* NET  5975 = abc_29733_new_n5168
* NET  5976 = abc_29733_new_n5167
* NET  5977 = abc_29733_new_n5166
* NET  5978 = abc_29733_new_n5165
* NET  5979 = abc_29733_new_n5164
* NET  5980 = abc_29733_new_n5162
* NET  5981 = abc_29733_new_n5161
* NET  5982 = abc_29733_new_n5160
* NET  5983 = abc_29733_new_n5159
* NET  5984 = abc_29733_new_n5158
* NET  5985 = abc_29733_new_n5157
* NET  5986 = abc_29733_new_n5156
* NET  5987 = abc_29733_new_n5155
* NET  5988 = abc_29733_new_n5154
* NET  5989 = abc_29733_new_n5152
* NET  5990 = abc_29733_new_n5151
* NET  5991 = abc_29733_new_n5150
* NET  5992 = abc_29733_new_n5149
* NET  5993 = abc_29733_new_n5148
* NET  5994 = abc_29733_new_n5147
* NET  5995 = abc_29733_new_n5146
* NET  5996 = abc_29733_new_n5145
* NET  5997 = abc_29733_new_n5144
* NET  5998 = abc_29733_new_n5143
* NET  5999 = abc_29733_new_n5141
* NET  6000 = abc_29733_new_n5140
* NET  6001 = abc_29733_new_n5139
* NET  6002 = abc_29733_new_n5138
* NET  6003 = abc_29733_new_n5137
* NET  6004 = abc_29733_new_n5136
* NET  6005 = abc_29733_new_n5135
* NET  6006 = abc_29733_new_n5134
* NET  6007 = abc_29733_new_n5133
* NET  6008 = abc_29733_new_n5132
* NET  6009 = abc_29733_new_n5130
* NET  6010 = abc_29733_new_n5129
* NET  6011 = abc_29733_new_n5128
* NET  6012 = abc_29733_new_n5127
* NET  6013 = abc_29733_new_n5126
* NET  6014 = abc_29733_new_n5125
* NET  6015 = abc_29733_new_n5124
* NET  6016 = abc_29733_new_n5123
* NET  6017 = abc_29733_new_n5122
* NET  6018 = abc_29733_new_n5120
* NET  6019 = abc_29733_new_n5119
* NET  6020 = abc_29733_new_n5118
* NET  6021 = abc_29733_new_n5117
* NET  6022 = abc_29733_new_n5116
* NET  6023 = abc_29733_new_n5115
* NET  6024 = abc_29733_new_n5114
* NET  6025 = abc_29733_new_n5113
* NET  6026 = abc_29733_new_n5112
* NET  6027 = abc_29733_new_n5110
* NET  6028 = abc_29733_new_n5109
* NET  6029 = abc_29733_new_n5108
* NET  6030 = abc_29733_new_n5107
* NET  6031 = abc_29733_new_n5106
* NET  6032 = abc_29733_new_n5105
* NET  6033 = abc_29733_new_n5104
* NET  6034 = abc_29733_new_n5103
* NET  6035 = abc_29733_new_n5102
* NET  6036 = abc_29733_new_n5101
* NET  6037 = abc_29733_new_n5100
* NET  6038 = abc_29733_new_n5098
* NET  6039 = abc_29733_new_n5097
* NET  6040 = abc_29733_new_n5096
* NET  6041 = abc_29733_new_n5095
* NET  6042 = abc_29733_new_n5094
* NET  6043 = abc_29733_new_n5093
* NET  6044 = abc_29733_new_n5092
* NET  6045 = abc_29733_new_n5091
* NET  6046 = abc_29733_new_n5090
* NET  6047 = abc_29733_new_n5088
* NET  6048 = abc_29733_new_n5087
* NET  6049 = abc_29733_new_n5086
* NET  6050 = abc_29733_new_n5085
* NET  6051 = abc_29733_new_n5084
* NET  6052 = abc_29733_new_n5083
* NET  6053 = abc_29733_new_n5082
* NET  6054 = abc_29733_new_n5081
* NET  6055 = abc_29733_new_n5080
* NET  6056 = abc_29733_new_n5079
* NET  6057 = abc_29733_new_n5077
* NET  6058 = abc_29733_new_n5076
* NET  6059 = abc_29733_new_n5075
* NET  6060 = abc_29733_new_n5074
* NET  6061 = abc_29733_new_n5073
* NET  6062 = abc_29733_new_n5072
* NET  6063 = abc_29733_new_n5071
* NET  6064 = abc_29733_new_n5070
* NET  6065 = abc_29733_new_n5068
* NET  6066 = abc_29733_new_n5067
* NET  6067 = abc_29733_new_n5066
* NET  6068 = abc_29733_new_n5065
* NET  6069 = abc_29733_new_n5064
* NET  6070 = abc_29733_new_n5063
* NET  6071 = abc_29733_new_n5062
* NET  6072 = abc_29733_new_n5061
* NET  6073 = abc_29733_new_n5060
* NET  6074 = abc_29733_new_n5059
* NET  6075 = abc_29733_new_n5058
* NET  6076 = abc_29733_new_n5056
* NET  6077 = abc_29733_new_n5055
* NET  6078 = abc_29733_new_n5054
* NET  6079 = abc_29733_new_n5053
* NET  6080 = abc_29733_new_n5052
* NET  6081 = abc_29733_new_n5051
* NET  6082 = abc_29733_new_n5050
* NET  6083 = abc_29733_new_n5048
* NET  6084 = abc_29733_new_n5047
* NET  6085 = abc_29733_new_n5046
* NET  6086 = abc_29733_new_n5045
* NET  6087 = abc_29733_new_n5044
* NET  6088 = abc_29733_new_n5043
* NET  6089 = abc_29733_new_n5042
* NET  6090 = abc_29733_new_n5041
* NET  6091 = abc_29733_new_n5040
* NET  6092 = abc_29733_new_n5038
* NET  6093 = abc_29733_new_n5037
* NET  6094 = abc_29733_new_n5036
* NET  6095 = abc_29733_new_n5035
* NET  6096 = abc_29733_new_n5034
* NET  6097 = abc_29733_new_n5033
* NET  6098 = abc_29733_new_n5032
* NET  6099 = abc_29733_new_n5030
* NET  6100 = abc_29733_new_n5029
* NET  6101 = abc_29733_new_n5028
* NET  6102 = abc_29733_new_n5027
* NET  6103 = abc_29733_new_n5026
* NET  6104 = abc_29733_new_n5025
* NET  6105 = abc_29733_new_n5023
* NET  6106 = abc_29733_new_n5022
* NET  6107 = abc_29733_new_n5021
* NET  6108 = abc_29733_new_n5020
* NET  6109 = abc_29733_new_n5019
* NET  6110 = abc_29733_new_n5018
* NET  6111 = abc_29733_new_n5017
* NET  6112 = abc_29733_new_n5016
* NET  6113 = abc_29733_new_n5015
* NET  6114 = abc_29733_new_n5014
* NET  6115 = abc_29733_new_n5013
* NET  6116 = abc_29733_new_n5012
* NET  6117 = abc_29733_new_n5011
* NET  6118 = abc_29733_new_n5010
* NET  6119 = abc_29733_new_n5009
* NET  6120 = abc_29733_new_n5008
* NET  6121 = abc_29733_new_n5007
* NET  6122 = abc_29733_new_n5006
* NET  6123 = abc_29733_new_n5005
* NET  6124 = abc_29733_new_n5004
* NET  6125 = abc_29733_new_n5003
* NET  6126 = abc_29733_new_n5002
* NET  6127 = abc_29733_new_n5001
* NET  6128 = abc_29733_new_n5000
* NET  6129 = abc_29733_new_n4999
* NET  6130 = abc_29733_new_n4998
* NET  6131 = abc_29733_new_n4997
* NET  6132 = abc_29733_new_n4996
* NET  6133 = abc_29733_new_n4995
* NET  6134 = abc_29733_new_n4994
* NET  6135 = abc_29733_new_n4993
* NET  6136 = abc_29733_new_n4992
* NET  6137 = abc_29733_new_n4991
* NET  6138 = abc_29733_new_n4990
* NET  6139 = abc_29733_new_n4989
* NET  6140 = abc_29733_new_n4988
* NET  6141 = abc_29733_new_n4987
* NET  6142 = abc_29733_new_n4986
* NET  6143 = abc_29733_new_n4985
* NET  6144 = abc_29733_new_n4984
* NET  6145 = abc_29733_new_n4983
* NET  6146 = abc_29733_new_n4982
* NET  6147 = abc_29733_new_n4981
* NET  6148 = abc_29733_new_n4980
* NET  6149 = abc_29733_new_n4979
* NET  6150 = abc_29733_new_n4978
* NET  6151 = abc_29733_new_n4977
* NET  6152 = abc_29733_new_n4976
* NET  6153 = abc_29733_new_n4975
* NET  6154 = abc_29733_new_n4974
* NET  6155 = abc_29733_new_n4973
* NET  6156 = abc_29733_new_n4972
* NET  6157 = abc_29733_new_n4971
* NET  6158 = abc_29733_new_n4970
* NET  6159 = abc_29733_new_n4969
* NET  6160 = abc_29733_new_n4968
* NET  6161 = abc_29733_new_n4967
* NET  6162 = abc_29733_new_n4966
* NET  6163 = abc_29733_new_n4965
* NET  6164 = abc_29733_new_n4964
* NET  6165 = abc_29733_new_n4963
* NET  6166 = abc_29733_new_n4962
* NET  6167 = abc_29733_new_n4961
* NET  6168 = abc_29733_new_n4960
* NET  6169 = abc_29733_new_n4959
* NET  6170 = abc_29733_new_n4958
* NET  6171 = abc_29733_new_n4957
* NET  6172 = abc_29733_new_n4956
* NET  6173 = abc_29733_new_n4955
* NET  6174 = abc_29733_new_n4954
* NET  6175 = abc_29733_new_n4953
* NET  6176 = abc_29733_new_n4952
* NET  6177 = abc_29733_new_n4951
* NET  6178 = abc_29733_new_n4950
* NET  6179 = abc_29733_new_n4949
* NET  6180 = abc_29733_new_n4948
* NET  6181 = abc_29733_new_n4947
* NET  6182 = abc_29733_new_n4946
* NET  6183 = abc_29733_new_n4945
* NET  6184 = abc_29733_new_n4944
* NET  6185 = abc_29733_new_n4943
* NET  6186 = abc_29733_new_n4942
* NET  6187 = abc_29733_new_n4941
* NET  6188 = abc_29733_new_n4940
* NET  6189 = abc_29733_new_n4939
* NET  6190 = abc_29733_new_n4938
* NET  6191 = abc_29733_new_n4937
* NET  6192 = abc_29733_new_n4936
* NET  6193 = abc_29733_new_n4935
* NET  6194 = abc_29733_new_n4934
* NET  6195 = abc_29733_new_n4933
* NET  6196 = abc_29733_new_n4932
* NET  6197 = abc_29733_new_n4931
* NET  6198 = abc_29733_new_n4930
* NET  6199 = abc_29733_new_n4929
* NET  6200 = abc_29733_new_n4928
* NET  6201 = abc_29733_new_n4927
* NET  6202 = abc_29733_new_n4926
* NET  6203 = abc_29733_new_n4925
* NET  6204 = abc_29733_new_n4924
* NET  6205 = abc_29733_new_n4923
* NET  6206 = abc_29733_new_n4922
* NET  6207 = abc_29733_new_n4921
* NET  6208 = abc_29733_new_n4920
* NET  6209 = abc_29733_new_n4919
* NET  6210 = abc_29733_new_n4918
* NET  6211 = abc_29733_new_n4917
* NET  6212 = abc_29733_new_n4916
* NET  6213 = abc_29733_new_n4915
* NET  6214 = abc_29733_new_n4914
* NET  6215 = abc_29733_new_n4913
* NET  6216 = abc_29733_new_n4912
* NET  6217 = abc_29733_new_n4911
* NET  6218 = abc_29733_new_n4910
* NET  6219 = abc_29733_new_n4909
* NET  6220 = abc_29733_new_n4908
* NET  6221 = abc_29733_new_n4907
* NET  6222 = abc_29733_new_n4906
* NET  6223 = abc_29733_new_n4905
* NET  6224 = abc_29733_new_n4904
* NET  6225 = abc_29733_new_n4903
* NET  6226 = abc_29733_new_n4902
* NET  6227 = abc_29733_new_n4901
* NET  6228 = abc_29733_new_n4900
* NET  6229 = abc_29733_new_n4899
* NET  6230 = abc_29733_new_n4898
* NET  6231 = abc_29733_new_n4897
* NET  6232 = abc_29733_new_n4896
* NET  6233 = abc_29733_new_n4895
* NET  6234 = abc_29733_new_n4894
* NET  6235 = abc_29733_new_n4893
* NET  6236 = abc_29733_new_n4892
* NET  6237 = abc_29733_new_n4891
* NET  6238 = abc_29733_new_n4890
* NET  6239 = abc_29733_new_n4889
* NET  6240 = abc_29733_new_n4888
* NET  6241 = abc_29733_new_n4887
* NET  6242 = abc_29733_new_n4886
* NET  6243 = abc_29733_new_n4885
* NET  6244 = abc_29733_new_n4884
* NET  6245 = abc_29733_new_n4883
* NET  6246 = abc_29733_new_n4882
* NET  6247 = abc_29733_new_n4881
* NET  6248 = abc_29733_new_n4880
* NET  6249 = abc_29733_new_n4879
* NET  6250 = abc_29733_new_n4878
* NET  6251 = abc_29733_new_n4877
* NET  6252 = abc_29733_new_n4876
* NET  6253 = abc_29733_new_n4875
* NET  6254 = abc_29733_new_n4874
* NET  6255 = abc_29733_new_n4873
* NET  6256 = abc_29733_new_n4872
* NET  6257 = abc_29733_new_n4871
* NET  6258 = abc_29733_new_n4870
* NET  6259 = abc_29733_new_n4869
* NET  6260 = abc_29733_new_n4868
* NET  6261 = abc_29733_new_n4867
* NET  6262 = abc_29733_new_n4866
* NET  6263 = abc_29733_new_n4865
* NET  6264 = abc_29733_new_n4864
* NET  6265 = abc_29733_new_n4863
* NET  6266 = abc_29733_new_n4862
* NET  6267 = abc_29733_new_n4861
* NET  6268 = abc_29733_new_n4860
* NET  6269 = abc_29733_new_n4859
* NET  6270 = abc_29733_new_n4858
* NET  6271 = abc_29733_new_n4857
* NET  6272 = abc_29733_new_n4856
* NET  6273 = abc_29733_new_n4855
* NET  6274 = abc_29733_new_n4854
* NET  6275 = abc_29733_new_n4853
* NET  6276 = abc_29733_new_n4852
* NET  6277 = abc_29733_new_n4851
* NET  6278 = abc_29733_new_n4850
* NET  6279 = abc_29733_new_n4849
* NET  6280 = abc_29733_new_n4848
* NET  6281 = abc_29733_new_n4847
* NET  6282 = abc_29733_new_n4846
* NET  6283 = abc_29733_new_n4845
* NET  6284 = abc_29733_new_n4844
* NET  6285 = abc_29733_new_n4843
* NET  6286 = abc_29733_new_n4842
* NET  6287 = abc_29733_new_n4841
* NET  6288 = abc_29733_new_n4840
* NET  6289 = abc_29733_new_n4839
* NET  6290 = abc_29733_new_n4838
* NET  6291 = abc_29733_new_n4837
* NET  6292 = abc_29733_new_n4836
* NET  6293 = abc_29733_new_n4835
* NET  6294 = abc_29733_new_n4834
* NET  6295 = abc_29733_new_n4833
* NET  6296 = abc_29733_new_n4832
* NET  6297 = abc_29733_new_n4831
* NET  6298 = abc_29733_new_n4830
* NET  6299 = abc_29733_new_n4829
* NET  6300 = abc_29733_new_n4828
* NET  6301 = abc_29733_new_n4827
* NET  6302 = abc_29733_new_n4826
* NET  6303 = abc_29733_new_n4825
* NET  6304 = abc_29733_new_n4824
* NET  6305 = abc_29733_new_n4823
* NET  6306 = abc_29733_new_n4822
* NET  6307 = abc_29733_new_n4821
* NET  6308 = abc_29733_new_n4820
* NET  6309 = abc_29733_new_n4819
* NET  6310 = abc_29733_new_n4818
* NET  6311 = abc_29733_new_n4817
* NET  6312 = abc_29733_new_n4816
* NET  6313 = abc_29733_new_n4815
* NET  6314 = abc_29733_new_n4814
* NET  6315 = abc_29733_new_n4813
* NET  6316 = abc_29733_new_n4812
* NET  6317 = abc_29733_new_n4811
* NET  6318 = abc_29733_new_n4810
* NET  6319 = abc_29733_new_n4809
* NET  6320 = abc_29733_new_n4808
* NET  6321 = abc_29733_new_n4807
* NET  6322 = abc_29733_new_n4806
* NET  6323 = abc_29733_new_n4805
* NET  6324 = abc_29733_new_n4804
* NET  6325 = abc_29733_new_n4803
* NET  6326 = abc_29733_new_n4802
* NET  6327 = abc_29733_new_n4801
* NET  6328 = abc_29733_new_n4800
* NET  6329 = abc_29733_new_n4799
* NET  6330 = abc_29733_new_n4798
* NET  6331 = abc_29733_new_n4797
* NET  6332 = abc_29733_new_n4796
* NET  6333 = abc_29733_new_n4795
* NET  6334 = abc_29733_new_n4794
* NET  6335 = abc_29733_new_n4793
* NET  6336 = abc_29733_new_n4792
* NET  6337 = abc_29733_new_n4791
* NET  6338 = abc_29733_new_n4790
* NET  6339 = abc_29733_new_n4789
* NET  6340 = abc_29733_new_n4788
* NET  6341 = abc_29733_new_n4787
* NET  6342 = abc_29733_new_n4786
* NET  6343 = abc_29733_new_n4785
* NET  6344 = abc_29733_new_n4784
* NET  6345 = abc_29733_new_n4783
* NET  6346 = abc_29733_new_n4782
* NET  6347 = abc_29733_new_n4781
* NET  6348 = abc_29733_new_n4780
* NET  6349 = abc_29733_new_n4779
* NET  6350 = abc_29733_new_n4778
* NET  6351 = abc_29733_new_n4777
* NET  6352 = abc_29733_new_n4776
* NET  6353 = abc_29733_new_n4775
* NET  6354 = abc_29733_new_n4774
* NET  6355 = abc_29733_new_n4773
* NET  6356 = abc_29733_new_n4772
* NET  6357 = abc_29733_new_n4771
* NET  6358 = abc_29733_new_n4770
* NET  6359 = abc_29733_new_n4769
* NET  6360 = abc_29733_new_n4768
* NET  6361 = abc_29733_new_n4767
* NET  6362 = abc_29733_new_n4766
* NET  6363 = abc_29733_new_n4765
* NET  6364 = abc_29733_new_n4764
* NET  6365 = abc_29733_new_n4763
* NET  6366 = abc_29733_new_n4762
* NET  6367 = abc_29733_new_n4761
* NET  6368 = abc_29733_new_n4760
* NET  6369 = abc_29733_new_n4759
* NET  6370 = abc_29733_new_n4758
* NET  6371 = abc_29733_new_n4757
* NET  6372 = abc_29733_new_n4756
* NET  6373 = abc_29733_new_n4755
* NET  6374 = abc_29733_new_n4754
* NET  6375 = abc_29733_new_n4753
* NET  6376 = abc_29733_new_n4752
* NET  6377 = abc_29733_new_n4751
* NET  6378 = abc_29733_new_n4750
* NET  6379 = abc_29733_new_n4749
* NET  6380 = abc_29733_new_n4748
* NET  6381 = abc_29733_new_n4747
* NET  6382 = abc_29733_new_n4746
* NET  6383 = abc_29733_new_n4745
* NET  6384 = abc_29733_new_n4744
* NET  6385 = abc_29733_new_n4743
* NET  6386 = abc_29733_new_n4742
* NET  6387 = abc_29733_new_n4741
* NET  6388 = abc_29733_new_n4740
* NET  6389 = abc_29733_new_n4739
* NET  6390 = abc_29733_new_n4738
* NET  6391 = abc_29733_new_n4737
* NET  6392 = abc_29733_new_n4736
* NET  6393 = abc_29733_new_n4735
* NET  6394 = abc_29733_new_n4734
* NET  6395 = abc_29733_new_n4733
* NET  6396 = abc_29733_new_n4732
* NET  6397 = abc_29733_new_n4731
* NET  6398 = abc_29733_new_n4730
* NET  6399 = abc_29733_new_n4729
* NET  6400 = abc_29733_new_n4728
* NET  6401 = abc_29733_new_n4727
* NET  6402 = abc_29733_new_n4726
* NET  6403 = abc_29733_new_n4725
* NET  6404 = abc_29733_new_n4724
* NET  6405 = abc_29733_new_n4723
* NET  6406 = abc_29733_new_n4722
* NET  6407 = abc_29733_new_n4721
* NET  6408 = abc_29733_new_n4720
* NET  6409 = abc_29733_new_n4719
* NET  6410 = abc_29733_new_n4718
* NET  6411 = abc_29733_new_n4717
* NET  6412 = abc_29733_new_n4716
* NET  6413 = abc_29733_new_n4715
* NET  6414 = abc_29733_new_n4714
* NET  6415 = abc_29733_new_n4713
* NET  6416 = abc_29733_new_n4712
* NET  6417 = abc_29733_new_n4711
* NET  6418 = abc_29733_new_n4710
* NET  6419 = abc_29733_new_n4709
* NET  6420 = abc_29733_new_n4708
* NET  6421 = abc_29733_new_n4707
* NET  6422 = abc_29733_new_n4706
* NET  6423 = abc_29733_new_n4705
* NET  6424 = abc_29733_new_n4704
* NET  6425 = abc_29733_new_n4703
* NET  6426 = abc_29733_new_n4702
* NET  6427 = abc_29733_new_n4701
* NET  6428 = abc_29733_new_n4700
* NET  6429 = abc_29733_new_n4699
* NET  6430 = abc_29733_new_n4698
* NET  6431 = abc_29733_new_n4697
* NET  6432 = abc_29733_new_n4695
* NET  6433 = abc_29733_new_n4694
* NET  6434 = abc_29733_new_n4693
* NET  6435 = abc_29733_new_n4692
* NET  6436 = abc_29733_new_n4691
* NET  6437 = abc_29733_new_n4690
* NET  6438 = abc_29733_new_n4689
* NET  6439 = abc_29733_new_n4688
* NET  6440 = abc_29733_new_n4687
* NET  6441 = abc_29733_new_n4686
* NET  6442 = abc_29733_new_n4685
* NET  6443 = abc_29733_new_n4684
* NET  6444 = abc_29733_new_n4683
* NET  6445 = abc_29733_new_n4682
* NET  6446 = abc_29733_new_n4680
* NET  6447 = abc_29733_new_n4679
* NET  6448 = abc_29733_new_n4678
* NET  6449 = abc_29733_new_n4677
* NET  6450 = abc_29733_new_n4676
* NET  6451 = abc_29733_new_n4675
* NET  6452 = abc_29733_new_n4674
* NET  6453 = abc_29733_new_n4673
* NET  6454 = abc_29733_new_n4672
* NET  6455 = abc_29733_new_n4671
* NET  6456 = abc_29733_new_n4670
* NET  6457 = abc_29733_new_n4669
* NET  6458 = abc_29733_new_n4668
* NET  6459 = abc_29733_new_n4667
* NET  6460 = abc_29733_new_n4666
* NET  6461 = abc_29733_new_n4665
* NET  6462 = abc_29733_new_n4663
* NET  6463 = abc_29733_new_n4662
* NET  6464 = abc_29733_new_n4661
* NET  6465 = abc_29733_new_n4660
* NET  6466 = abc_29733_new_n4659
* NET  6467 = abc_29733_new_n4658
* NET  6468 = abc_29733_new_n4657
* NET  6469 = abc_29733_new_n4656
* NET  6470 = abc_29733_new_n4655
* NET  6471 = abc_29733_new_n4654
* NET  6472 = abc_29733_new_n4653
* NET  6473 = abc_29733_new_n4652
* NET  6474 = abc_29733_new_n4651
* NET  6475 = abc_29733_new_n4650
* NET  6476 = abc_29733_new_n4649
* NET  6477 = abc_29733_new_n4648
* NET  6478 = abc_29733_new_n4647
* NET  6479 = abc_29733_new_n4646
* NET  6480 = abc_29733_new_n4644
* NET  6481 = abc_29733_new_n4643
* NET  6482 = abc_29733_new_n4642
* NET  6483 = abc_29733_new_n4641
* NET  6484 = abc_29733_new_n4640
* NET  6485 = abc_29733_new_n4639
* NET  6486 = abc_29733_new_n4638
* NET  6487 = abc_29733_new_n4637
* NET  6488 = abc_29733_new_n4636
* NET  6489 = abc_29733_new_n4635
* NET  6490 = abc_29733_new_n4634
* NET  6491 = abc_29733_new_n4633
* NET  6492 = abc_29733_new_n4632
* NET  6493 = abc_29733_new_n4631
* NET  6494 = abc_29733_new_n4630
* NET  6495 = abc_29733_new_n4629
* NET  6496 = abc_29733_new_n4628
* NET  6497 = abc_29733_new_n4627
* NET  6498 = abc_29733_new_n4625
* NET  6499 = abc_29733_new_n4624
* NET  6500 = abc_29733_new_n4623
* NET  6501 = abc_29733_new_n4622
* NET  6502 = abc_29733_new_n4621
* NET  6503 = abc_29733_new_n4620
* NET  6504 = abc_29733_new_n4619
* NET  6505 = abc_29733_new_n4618
* NET  6506 = abc_29733_new_n4617
* NET  6507 = abc_29733_new_n4616
* NET  6508 = abc_29733_new_n4615
* NET  6509 = abc_29733_new_n4614
* NET  6510 = abc_29733_new_n4613
* NET  6511 = abc_29733_new_n4612
* NET  6512 = abc_29733_new_n4611
* NET  6513 = abc_29733_new_n4610
* NET  6514 = abc_29733_new_n4609
* NET  6515 = abc_29733_new_n4608
* NET  6516 = abc_29733_new_n4606
* NET  6517 = abc_29733_new_n4605
* NET  6518 = abc_29733_new_n4604
* NET  6519 = abc_29733_new_n4603
* NET  6520 = abc_29733_new_n4602
* NET  6521 = abc_29733_new_n4601
* NET  6522 = abc_29733_new_n4600
* NET  6523 = abc_29733_new_n4599
* NET  6524 = abc_29733_new_n4598
* NET  6525 = abc_29733_new_n4597
* NET  6526 = abc_29733_new_n4596
* NET  6527 = abc_29733_new_n4595
* NET  6528 = abc_29733_new_n4594
* NET  6529 = abc_29733_new_n4593
* NET  6530 = abc_29733_new_n4592
* NET  6531 = abc_29733_new_n4591
* NET  6532 = abc_29733_new_n4590
* NET  6533 = abc_29733_new_n4589
* NET  6534 = abc_29733_new_n4587
* NET  6535 = abc_29733_new_n4586
* NET  6536 = abc_29733_new_n4585
* NET  6537 = abc_29733_new_n4584
* NET  6538 = abc_29733_new_n4583
* NET  6539 = abc_29733_new_n4582
* NET  6540 = abc_29733_new_n4581
* NET  6541 = abc_29733_new_n4580
* NET  6542 = abc_29733_new_n4579
* NET  6543 = abc_29733_new_n4578
* NET  6544 = abc_29733_new_n4577
* NET  6545 = abc_29733_new_n4576
* NET  6546 = abc_29733_new_n4575
* NET  6547 = abc_29733_new_n4574
* NET  6548 = abc_29733_new_n4573
* NET  6549 = abc_29733_new_n4572
* NET  6550 = abc_29733_new_n4571
* NET  6551 = abc_29733_new_n4570
* NET  6552 = abc_29733_new_n4568
* NET  6553 = abc_29733_new_n4567
* NET  6554 = abc_29733_new_n4566
* NET  6555 = abc_29733_new_n4565
* NET  6556 = abc_29733_new_n4564
* NET  6557 = abc_29733_new_n4563
* NET  6558 = abc_29733_new_n4562
* NET  6559 = abc_29733_new_n4561
* NET  6560 = abc_29733_new_n4560
* NET  6561 = abc_29733_new_n4559
* NET  6562 = abc_29733_new_n4558
* NET  6563 = abc_29733_new_n4557
* NET  6564 = abc_29733_new_n4556
* NET  6565 = abc_29733_new_n4555
* NET  6566 = abc_29733_new_n4554
* NET  6567 = abc_29733_new_n4553
* NET  6568 = abc_29733_new_n4552
* NET  6569 = abc_29733_new_n4551
* NET  6570 = abc_29733_new_n4549
* NET  6571 = abc_29733_new_n4548
* NET  6572 = abc_29733_new_n4547
* NET  6573 = abc_29733_new_n4546
* NET  6574 = abc_29733_new_n4545
* NET  6575 = abc_29733_new_n4544
* NET  6576 = abc_29733_new_n4543
* NET  6577 = abc_29733_new_n4542
* NET  6578 = abc_29733_new_n4541
* NET  6579 = abc_29733_new_n4540
* NET  6580 = abc_29733_new_n4539
* NET  6581 = abc_29733_new_n4538
* NET  6582 = abc_29733_new_n4537
* NET  6583 = abc_29733_new_n4536
* NET  6584 = abc_29733_new_n4535
* NET  6585 = abc_29733_new_n4534
* NET  6586 = abc_29733_new_n4533
* NET  6587 = abc_29733_new_n4532
* NET  6588 = abc_29733_new_n4530
* NET  6589 = abc_29733_new_n4529
* NET  6590 = abc_29733_new_n4528
* NET  6591 = abc_29733_new_n4527
* NET  6592 = abc_29733_new_n4526
* NET  6593 = abc_29733_new_n4525
* NET  6594 = abc_29733_new_n4524
* NET  6595 = abc_29733_new_n4523
* NET  6596 = abc_29733_new_n4522
* NET  6597 = abc_29733_new_n4521
* NET  6598 = abc_29733_new_n4520
* NET  6599 = abc_29733_new_n4519
* NET  6600 = abc_29733_new_n4518
* NET  6601 = abc_29733_new_n4517
* NET  6602 = abc_29733_new_n4516
* NET  6603 = abc_29733_new_n4515
* NET  6604 = abc_29733_new_n4514
* NET  6605 = abc_29733_new_n4513
* NET  6606 = abc_29733_new_n4511
* NET  6607 = abc_29733_new_n4510
* NET  6608 = abc_29733_new_n4509
* NET  6609 = abc_29733_new_n4508
* NET  6610 = abc_29733_new_n4507
* NET  6611 = abc_29733_new_n4506
* NET  6612 = abc_29733_new_n4505
* NET  6613 = abc_29733_new_n4504
* NET  6614 = abc_29733_new_n4503
* NET  6615 = abc_29733_new_n4502
* NET  6616 = abc_29733_new_n4501
* NET  6617 = abc_29733_new_n4500
* NET  6618 = abc_29733_new_n4499
* NET  6619 = abc_29733_new_n4498
* NET  6620 = abc_29733_new_n4497
* NET  6621 = abc_29733_new_n4496
* NET  6622 = abc_29733_new_n4495
* NET  6623 = abc_29733_new_n4494
* NET  6624 = abc_29733_new_n4492
* NET  6625 = abc_29733_new_n4491
* NET  6626 = abc_29733_new_n4490
* NET  6627 = abc_29733_new_n4489
* NET  6628 = abc_29733_new_n4488
* NET  6629 = abc_29733_new_n4487
* NET  6630 = abc_29733_new_n4486
* NET  6631 = abc_29733_new_n4485
* NET  6632 = abc_29733_new_n4484
* NET  6633 = abc_29733_new_n4483
* NET  6634 = abc_29733_new_n4482
* NET  6635 = abc_29733_new_n4481
* NET  6636 = abc_29733_new_n4480
* NET  6637 = abc_29733_new_n4479
* NET  6638 = abc_29733_new_n4478
* NET  6639 = abc_29733_new_n4477
* NET  6640 = abc_29733_new_n4476
* NET  6641 = abc_29733_new_n4475
* NET  6642 = abc_29733_new_n4474
* NET  6643 = abc_29733_new_n4473
* NET  6644 = abc_29733_new_n4471
* NET  6645 = abc_29733_new_n4470
* NET  6646 = abc_29733_new_n4469
* NET  6647 = abc_29733_new_n4468
* NET  6648 = abc_29733_new_n4467
* NET  6649 = abc_29733_new_n4466
* NET  6650 = abc_29733_new_n4465
* NET  6651 = abc_29733_new_n4464
* NET  6652 = abc_29733_new_n4463
* NET  6653 = abc_29733_new_n4462
* NET  6654 = abc_29733_new_n4461
* NET  6655 = abc_29733_new_n4460
* NET  6656 = abc_29733_new_n4459
* NET  6657 = abc_29733_new_n4458
* NET  6658 = abc_29733_new_n4457
* NET  6659 = abc_29733_new_n4456
* NET  6660 = abc_29733_new_n4455
* NET  6661 = abc_29733_new_n4454
* NET  6662 = abc_29733_new_n4452
* NET  6663 = abc_29733_new_n4451
* NET  6664 = abc_29733_new_n4450
* NET  6665 = abc_29733_new_n4449
* NET  6666 = abc_29733_new_n4448
* NET  6667 = abc_29733_new_n4447
* NET  6668 = abc_29733_new_n4446
* NET  6669 = abc_29733_new_n4445
* NET  6670 = abc_29733_new_n4444
* NET  6671 = abc_29733_new_n4443
* NET  6672 = abc_29733_new_n4442
* NET  6673 = abc_29733_new_n4441
* NET  6674 = abc_29733_new_n4440
* NET  6675 = abc_29733_new_n4439
* NET  6676 = abc_29733_new_n4438
* NET  6677 = abc_29733_new_n4437
* NET  6678 = abc_29733_new_n4435
* NET  6679 = abc_29733_new_n4434
* NET  6680 = abc_29733_new_n4433
* NET  6681 = abc_29733_new_n4432
* NET  6682 = abc_29733_new_n4431
* NET  6683 = abc_29733_new_n4430
* NET  6684 = abc_29733_new_n4429
* NET  6685 = abc_29733_new_n4428
* NET  6686 = abc_29733_new_n4427
* NET  6687 = abc_29733_new_n4426
* NET  6688 = abc_29733_new_n4425
* NET  6689 = abc_29733_new_n4424
* NET  6690 = abc_29733_new_n4423
* NET  6691 = abc_29733_new_n4422
* NET  6692 = abc_29733_new_n4421
* NET  6693 = abc_29733_new_n4419
* NET  6694 = abc_29733_new_n4418
* NET  6695 = abc_29733_new_n4417
* NET  6696 = abc_29733_new_n4416
* NET  6697 = abc_29733_new_n4415
* NET  6698 = abc_29733_new_n4414
* NET  6699 = abc_29733_new_n4413
* NET  6700 = abc_29733_new_n4412
* NET  6701 = abc_29733_new_n4411
* NET  6702 = abc_29733_new_n4410
* NET  6703 = abc_29733_new_n4409
* NET  6704 = abc_29733_new_n4408
* NET  6705 = abc_29733_new_n4407
* NET  6706 = abc_29733_new_n4406
* NET  6707 = abc_29733_new_n4405
* NET  6708 = abc_29733_new_n4404
* NET  6709 = abc_29733_new_n4403
* NET  6710 = abc_29733_new_n4401
* NET  6711 = abc_29733_new_n4400
* NET  6712 = abc_29733_new_n4399
* NET  6713 = abc_29733_new_n4398
* NET  6714 = abc_29733_new_n4397
* NET  6715 = abc_29733_new_n4396
* NET  6716 = abc_29733_new_n4395
* NET  6717 = abc_29733_new_n4394
* NET  6718 = abc_29733_new_n4393
* NET  6719 = abc_29733_new_n4392
* NET  6720 = abc_29733_new_n4391
* NET  6721 = abc_29733_new_n4390
* NET  6722 = abc_29733_new_n4389
* NET  6723 = abc_29733_new_n4388
* NET  6724 = abc_29733_new_n4387
* NET  6725 = abc_29733_new_n4386
* NET  6726 = abc_29733_new_n4385
* NET  6727 = abc_29733_new_n4384
* NET  6728 = abc_29733_new_n4383
* NET  6729 = abc_29733_new_n4382
* NET  6730 = abc_29733_new_n4381
* NET  6731 = abc_29733_new_n4380
* NET  6732 = abc_29733_new_n4379
* NET  6733 = abc_29733_new_n4378
* NET  6734 = abc_29733_new_n4376
* NET  6735 = abc_29733_new_n4375
* NET  6736 = abc_29733_new_n4374
* NET  6737 = abc_29733_new_n4373
* NET  6738 = abc_29733_new_n4372
* NET  6739 = abc_29733_new_n4371
* NET  6740 = abc_29733_new_n4370
* NET  6741 = abc_29733_new_n4369
* NET  6742 = abc_29733_new_n4368
* NET  6743 = abc_29733_new_n4367
* NET  6744 = abc_29733_new_n4366
* NET  6745 = abc_29733_new_n4365
* NET  6746 = abc_29733_new_n4364
* NET  6747 = abc_29733_new_n4363
* NET  6748 = abc_29733_new_n4362
* NET  6749 = abc_29733_new_n4361
* NET  6750 = abc_29733_new_n4360
* NET  6751 = abc_29733_new_n4359
* NET  6752 = abc_29733_new_n4358
* NET  6753 = abc_29733_new_n4357
* NET  6754 = abc_29733_new_n4356
* NET  6755 = abc_29733_new_n4355
* NET  6756 = abc_29733_new_n4354
* NET  6757 = abc_29733_new_n4352
* NET  6758 = abc_29733_new_n4351
* NET  6759 = abc_29733_new_n4350
* NET  6760 = abc_29733_new_n4349
* NET  6761 = abc_29733_new_n4348
* NET  6762 = abc_29733_new_n4347
* NET  6763 = abc_29733_new_n4346
* NET  6764 = abc_29733_new_n4345
* NET  6765 = abc_29733_new_n4344
* NET  6766 = abc_29733_new_n4343
* NET  6767 = abc_29733_new_n4342
* NET  6768 = abc_29733_new_n4341
* NET  6769 = abc_29733_new_n4340
* NET  6770 = abc_29733_new_n4339
* NET  6771 = abc_29733_new_n4338
* NET  6772 = abc_29733_new_n4337
* NET  6773 = abc_29733_new_n4336
* NET  6774 = abc_29733_new_n4335
* NET  6775 = abc_29733_new_n4334
* NET  6776 = abc_29733_new_n4333
* NET  6777 = abc_29733_new_n4332
* NET  6778 = abc_29733_new_n4331
* NET  6779 = abc_29733_new_n4329
* NET  6780 = abc_29733_new_n4328
* NET  6781 = abc_29733_new_n4327
* NET  6782 = abc_29733_new_n4326
* NET  6783 = abc_29733_new_n4325
* NET  6784 = abc_29733_new_n4324
* NET  6785 = abc_29733_new_n4323
* NET  6786 = abc_29733_new_n4322
* NET  6787 = abc_29733_new_n4321
* NET  6788 = abc_29733_new_n4320
* NET  6789 = abc_29733_new_n4319
* NET  6790 = abc_29733_new_n4318
* NET  6791 = abc_29733_new_n4317
* NET  6792 = abc_29733_new_n4316
* NET  6793 = abc_29733_new_n4315
* NET  6794 = abc_29733_new_n4314
* NET  6795 = abc_29733_new_n4313
* NET  6796 = abc_29733_new_n4312
* NET  6797 = abc_29733_new_n4311
* NET  6798 = abc_29733_new_n4310
* NET  6799 = abc_29733_new_n4309
* NET  6800 = abc_29733_new_n4307
* NET  6801 = abc_29733_new_n4306
* NET  6802 = abc_29733_new_n4305
* NET  6803 = abc_29733_new_n4304
* NET  6804 = abc_29733_new_n4303
* NET  6805 = abc_29733_new_n4302
* NET  6806 = abc_29733_new_n4301
* NET  6807 = abc_29733_new_n4300
* NET  6808 = abc_29733_new_n4299
* NET  6809 = abc_29733_new_n4298
* NET  6810 = abc_29733_new_n4297
* NET  6811 = abc_29733_new_n4296
* NET  6812 = abc_29733_new_n4295
* NET  6813 = abc_29733_new_n4294
* NET  6814 = abc_29733_new_n4293
* NET  6815 = abc_29733_new_n4292
* NET  6816 = abc_29733_new_n4291
* NET  6817 = abc_29733_new_n4290
* NET  6818 = abc_29733_new_n4289
* NET  6819 = abc_29733_new_n4288
* NET  6820 = abc_29733_new_n4286
* NET  6821 = abc_29733_new_n4285
* NET  6822 = abc_29733_new_n4284
* NET  6823 = abc_29733_new_n4283
* NET  6824 = abc_29733_new_n4282
* NET  6825 = abc_29733_new_n4281
* NET  6826 = abc_29733_new_n4280
* NET  6827 = abc_29733_new_n4279
* NET  6828 = abc_29733_new_n4278
* NET  6829 = abc_29733_new_n4277
* NET  6830 = abc_29733_new_n4276
* NET  6831 = abc_29733_new_n4275
* NET  6832 = abc_29733_new_n4274
* NET  6833 = abc_29733_new_n4273
* NET  6834 = abc_29733_new_n4272
* NET  6835 = abc_29733_new_n4271
* NET  6836 = abc_29733_new_n4270
* NET  6837 = abc_29733_new_n4269
* NET  6838 = abc_29733_new_n4268
* NET  6839 = abc_29733_new_n4267
* NET  6840 = abc_29733_new_n4266
* NET  6841 = abc_29733_new_n4265
* NET  6842 = abc_29733_new_n4264
* NET  6843 = abc_29733_new_n4263
* NET  6844 = abc_29733_new_n4261
* NET  6845 = abc_29733_new_n4260
* NET  6846 = abc_29733_new_n4259
* NET  6847 = abc_29733_new_n4258
* NET  6848 = abc_29733_new_n4257
* NET  6849 = abc_29733_new_n4256
* NET  6850 = abc_29733_new_n4255
* NET  6851 = abc_29733_new_n4254
* NET  6852 = abc_29733_new_n4253
* NET  6853 = abc_29733_new_n4252
* NET  6854 = abc_29733_new_n4251
* NET  6855 = abc_29733_new_n4250
* NET  6856 = abc_29733_new_n4249
* NET  6857 = abc_29733_new_n4248
* NET  6858 = abc_29733_new_n4247
* NET  6859 = abc_29733_new_n4246
* NET  6860 = abc_29733_new_n4245
* NET  6861 = abc_29733_new_n4244
* NET  6862 = abc_29733_new_n4243
* NET  6863 = abc_29733_new_n4242
* NET  6864 = abc_29733_new_n4241
* NET  6865 = abc_29733_new_n4240
* NET  6866 = abc_29733_new_n4238
* NET  6867 = abc_29733_new_n4237
* NET  6868 = abc_29733_new_n4236
* NET  6869 = abc_29733_new_n4235
* NET  6870 = abc_29733_new_n4234
* NET  6871 = abc_29733_new_n4233
* NET  6872 = abc_29733_new_n4232
* NET  6873 = abc_29733_new_n4231
* NET  6874 = abc_29733_new_n4230
* NET  6875 = abc_29733_new_n4229
* NET  6876 = abc_29733_new_n4228
* NET  6877 = abc_29733_new_n4227
* NET  6878 = abc_29733_new_n4226
* NET  6879 = abc_29733_new_n4225
* NET  6880 = abc_29733_new_n4224
* NET  6881 = abc_29733_new_n4223
* NET  6882 = abc_29733_new_n4222
* NET  6883 = abc_29733_new_n4221
* NET  6884 = abc_29733_new_n4220
* NET  6885 = abc_29733_new_n4219
* NET  6886 = abc_29733_new_n4218
* NET  6887 = abc_29733_new_n4217
* NET  6888 = abc_29733_new_n4216
* NET  6889 = abc_29733_new_n4215
* NET  6890 = abc_29733_new_n4213
* NET  6891 = abc_29733_new_n4212
* NET  6892 = abc_29733_new_n4211
* NET  6893 = abc_29733_new_n4210
* NET  6894 = abc_29733_new_n4209
* NET  6895 = abc_29733_new_n4208
* NET  6896 = abc_29733_new_n4207
* NET  6897 = abc_29733_new_n4206
* NET  6898 = abc_29733_new_n4205
* NET  6899 = abc_29733_new_n4204
* NET  6900 = abc_29733_new_n4203
* NET  6901 = abc_29733_new_n4202
* NET  6902 = abc_29733_new_n4201
* NET  6903 = abc_29733_new_n4200
* NET  6904 = abc_29733_new_n4199
* NET  6905 = abc_29733_new_n4198
* NET  6906 = abc_29733_new_n4197
* NET  6907 = abc_29733_new_n4196
* NET  6908 = abc_29733_new_n4195
* NET  6909 = abc_29733_new_n4194
* NET  6910 = abc_29733_new_n4192
* NET  6911 = abc_29733_new_n4191
* NET  6912 = abc_29733_new_n4190
* NET  6913 = abc_29733_new_n4189
* NET  6914 = abc_29733_new_n4188
* NET  6915 = abc_29733_new_n4187
* NET  6916 = abc_29733_new_n4186
* NET  6917 = abc_29733_new_n4185
* NET  6918 = abc_29733_new_n4184
* NET  6919 = abc_29733_new_n4183
* NET  6920 = abc_29733_new_n4182
* NET  6921 = abc_29733_new_n4181
* NET  6922 = abc_29733_new_n4180
* NET  6923 = abc_29733_new_n4179
* NET  6924 = abc_29733_new_n4178
* NET  6925 = abc_29733_new_n4177
* NET  6926 = abc_29733_new_n4176
* NET  6927 = abc_29733_new_n4175
* NET  6928 = abc_29733_new_n4174
* NET  6929 = abc_29733_new_n4172
* NET  6930 = abc_29733_new_n4171
* NET  6931 = abc_29733_new_n4170
* NET  6932 = abc_29733_new_n4169
* NET  6933 = abc_29733_new_n4168
* NET  6934 = abc_29733_new_n4167
* NET  6935 = abc_29733_new_n4166
* NET  6936 = abc_29733_new_n4165
* NET  6937 = abc_29733_new_n4164
* NET  6938 = abc_29733_new_n4163
* NET  6939 = abc_29733_new_n4162
* NET  6940 = abc_29733_new_n4161
* NET  6941 = abc_29733_new_n4160
* NET  6942 = abc_29733_new_n4159
* NET  6943 = abc_29733_new_n4158
* NET  6944 = abc_29733_new_n4157
* NET  6945 = abc_29733_new_n4156
* NET  6946 = abc_29733_new_n4155
* NET  6947 = abc_29733_new_n4154
* NET  6948 = abc_29733_new_n4152
* NET  6949 = abc_29733_new_n4151
* NET  6950 = abc_29733_new_n4150
* NET  6951 = abc_29733_new_n4149
* NET  6952 = abc_29733_new_n4148
* NET  6953 = abc_29733_new_n4147
* NET  6954 = abc_29733_new_n4146
* NET  6955 = abc_29733_new_n4145
* NET  6956 = abc_29733_new_n4144
* NET  6957 = abc_29733_new_n4143
* NET  6958 = abc_29733_new_n4142
* NET  6959 = abc_29733_new_n4141
* NET  6960 = abc_29733_new_n4140
* NET  6961 = abc_29733_new_n4139
* NET  6962 = abc_29733_new_n4138
* NET  6963 = abc_29733_new_n4137
* NET  6964 = abc_29733_new_n4136
* NET  6965 = abc_29733_new_n4135
* NET  6966 = abc_29733_new_n4134
* NET  6967 = abc_29733_new_n4133
* NET  6968 = abc_29733_new_n4131
* NET  6969 = abc_29733_new_n4130
* NET  6970 = abc_29733_new_n4129
* NET  6971 = abc_29733_new_n4128
* NET  6972 = abc_29733_new_n4127
* NET  6973 = abc_29733_new_n4126
* NET  6974 = abc_29733_new_n4125
* NET  6975 = abc_29733_new_n4124
* NET  6976 = abc_29733_new_n4123
* NET  6977 = abc_29733_new_n4122
* NET  6978 = abc_29733_new_n4121
* NET  6979 = abc_29733_new_n4120
* NET  6980 = abc_29733_new_n4119
* NET  6981 = abc_29733_new_n4118
* NET  6982 = abc_29733_new_n4117
* NET  6983 = abc_29733_new_n4116
* NET  6984 = abc_29733_new_n4115
* NET  6985 = abc_29733_new_n4114
* NET  6986 = abc_29733_new_n4113
* NET  6987 = abc_29733_new_n4112
* NET  6988 = abc_29733_new_n4111
* NET  6989 = abc_29733_new_n4109
* NET  6990 = abc_29733_new_n4108
* NET  6991 = abc_29733_new_n4107
* NET  6992 = abc_29733_new_n4106
* NET  6993 = abc_29733_new_n4105
* NET  6994 = abc_29733_new_n4104
* NET  6995 = abc_29733_new_n4103
* NET  6996 = abc_29733_new_n4102
* NET  6997 = abc_29733_new_n4101
* NET  6998 = abc_29733_new_n4100
* NET  6999 = abc_29733_new_n4099
* NET  7000 = abc_29733_new_n4098
* NET  7001 = abc_29733_new_n4097
* NET  7002 = abc_29733_new_n4096
* NET  7003 = abc_29733_new_n4095
* NET  7004 = abc_29733_new_n4094
* NET  7005 = abc_29733_new_n4093
* NET  7006 = abc_29733_new_n4092
* NET  7007 = abc_29733_new_n4091
* NET  7008 = abc_29733_new_n4090
* NET  7009 = abc_29733_new_n4089
* NET  7010 = abc_29733_new_n4087
* NET  7011 = abc_29733_new_n4086
* NET  7012 = abc_29733_new_n4085
* NET  7013 = abc_29733_new_n4084
* NET  7014 = abc_29733_new_n4083
* NET  7015 = abc_29733_new_n4082
* NET  7016 = abc_29733_new_n4081
* NET  7017 = abc_29733_new_n4080
* NET  7018 = abc_29733_new_n4079
* NET  7019 = abc_29733_new_n4078
* NET  7020 = abc_29733_new_n4077
* NET  7021 = abc_29733_new_n4076
* NET  7022 = abc_29733_new_n4075
* NET  7023 = abc_29733_new_n4074
* NET  7024 = abc_29733_new_n4073
* NET  7025 = abc_29733_new_n4072
* NET  7026 = abc_29733_new_n4071
* NET  7027 = abc_29733_new_n4069
* NET  7028 = abc_29733_new_n4068
* NET  7029 = abc_29733_new_n4067
* NET  7030 = abc_29733_new_n4066
* NET  7031 = abc_29733_new_n4065
* NET  7032 = abc_29733_new_n4064
* NET  7033 = abc_29733_new_n4063
* NET  7034 = abc_29733_new_n4062
* NET  7035 = abc_29733_new_n4061
* NET  7036 = abc_29733_new_n4060
* NET  7037 = abc_29733_new_n4059
* NET  7038 = abc_29733_new_n4058
* NET  7039 = abc_29733_new_n4057
* NET  7040 = abc_29733_new_n4056
* NET  7041 = abc_29733_new_n4054
* NET  7042 = abc_29733_new_n4053
* NET  7043 = abc_29733_new_n4052
* NET  7044 = abc_29733_new_n4051
* NET  7045 = abc_29733_new_n4050
* NET  7046 = abc_29733_new_n4049
* NET  7047 = abc_29733_new_n4048
* NET  7048 = abc_29733_new_n4047
* NET  7049 = abc_29733_new_n4046
* NET  7050 = abc_29733_new_n4045
* NET  7051 = abc_29733_new_n4044
* NET  7052 = abc_29733_new_n4043
* NET  7053 = abc_29733_new_n4042
* NET  7054 = abc_29733_new_n4040
* NET  7055 = abc_29733_new_n4038
* NET  7056 = abc_29733_new_n4037
* NET  7057 = abc_29733_new_n4036
* NET  7058 = abc_29733_new_n4034
* NET  7059 = abc_29733_new_n4033
* NET  7060 = abc_29733_new_n4032
* NET  7061 = abc_29733_new_n4031
* NET  7062 = abc_29733_new_n4029
* NET  7063 = abc_29733_new_n4028
* NET  7064 = abc_29733_new_n4027
* NET  7065 = abc_29733_new_n4026
* NET  7066 = abc_29733_new_n4025
* NET  7067 = abc_29733_new_n4024
* NET  7068 = abc_29733_new_n4023
* NET  7069 = abc_29733_new_n4021
* NET  7070 = abc_29733_new_n4020
* NET  7071 = abc_29733_new_n4019
* NET  7072 = abc_29733_new_n4018
* NET  7073 = abc_29733_new_n4017
* NET  7074 = abc_29733_new_n4016
* NET  7075 = abc_29733_new_n4015
* NET  7076 = abc_29733_new_n4014
* NET  7077 = abc_29733_new_n4013
* NET  7078 = abc_29733_new_n4012
* NET  7079 = abc_29733_new_n4011
* NET  7080 = abc_29733_new_n4010
* NET  7081 = abc_29733_new_n4009
* NET  7082 = abc_29733_new_n4008
* NET  7083 = abc_29733_new_n4007
* NET  7084 = abc_29733_new_n4005
* NET  7085 = abc_29733_new_n4004
* NET  7086 = abc_29733_new_n4003
* NET  7087 = abc_29733_new_n4002
* NET  7088 = abc_29733_new_n4000
* NET  7089 = abc_29733_new_n3999
* NET  7090 = abc_29733_new_n3998
* NET  7091 = abc_29733_new_n3997
* NET  7092 = abc_29733_new_n3996
* NET  7093 = abc_29733_new_n3995
* NET  7094 = abc_29733_new_n3994
* NET  7095 = abc_29733_new_n3993
* NET  7096 = abc_29733_new_n3992
* NET  7097 = abc_29733_new_n3991
* NET  7098 = abc_29733_new_n3990
* NET  7099 = abc_29733_new_n3989
* NET  7100 = abc_29733_new_n3988
* NET  7101 = abc_29733_new_n3987
* NET  7102 = abc_29733_new_n3986
* NET  7103 = abc_29733_new_n3985
* NET  7104 = abc_29733_new_n3984
* NET  7105 = abc_29733_new_n3983
* NET  7106 = abc_29733_new_n3982
* NET  7107 = abc_29733_new_n3981
* NET  7108 = abc_29733_new_n3980
* NET  7109 = abc_29733_new_n3979
* NET  7110 = abc_29733_new_n3978
* NET  7111 = abc_29733_new_n3976
* NET  7112 = abc_29733_new_n3975
* NET  7113 = abc_29733_new_n3974
* NET  7114 = abc_29733_new_n3970
* NET  7115 = abc_29733_new_n3969
* NET  7116 = abc_29733_new_n3968
* NET  7117 = abc_29733_new_n3967
* NET  7118 = abc_29733_new_n3965
* NET  7119 = abc_29733_new_n3964
* NET  7120 = abc_29733_new_n3963
* NET  7121 = abc_29733_new_n3962
* NET  7122 = abc_29733_new_n3960
* NET  7123 = abc_29733_new_n3959
* NET  7124 = abc_29733_new_n3958
* NET  7125 = abc_29733_new_n3957
* NET  7126 = abc_29733_new_n3956
* NET  7127 = abc_29733_new_n3955
* NET  7128 = abc_29733_new_n3954
* NET  7129 = abc_29733_new_n3953
* NET  7130 = abc_29733_new_n3952
* NET  7131 = abc_29733_new_n3951
* NET  7132 = abc_29733_new_n3950
* NET  7133 = abc_29733_new_n3949
* NET  7134 = abc_29733_new_n3948
* NET  7135 = abc_29733_new_n3947
* NET  7136 = abc_29733_new_n3946
* NET  7137 = abc_29733_new_n3945
* NET  7138 = abc_29733_new_n3944
* NET  7139 = abc_29733_new_n3943
* NET  7140 = abc_29733_new_n3942
* NET  7141 = abc_29733_new_n3941
* NET  7142 = abc_29733_new_n3940
* NET  7143 = abc_29733_new_n3939
* NET  7144 = abc_29733_new_n3938
* NET  7145 = abc_29733_new_n3937
* NET  7146 = abc_29733_new_n3936
* NET  7147 = abc_29733_new_n3935
* NET  7148 = abc_29733_new_n3934
* NET  7149 = abc_29733_new_n3933
* NET  7150 = abc_29733_new_n3932
* NET  7151 = abc_29733_new_n3931
* NET  7152 = abc_29733_new_n3930
* NET  7153 = abc_29733_new_n3929
* NET  7154 = abc_29733_new_n3928
* NET  7155 = abc_29733_new_n3927
* NET  7156 = abc_29733_new_n3926
* NET  7157 = abc_29733_new_n3924
* NET  7158 = abc_29733_new_n3921
* NET  7159 = abc_29733_new_n3920
* NET  7160 = abc_29733_new_n3919
* NET  7161 = abc_29733_new_n3918
* NET  7162 = abc_29733_new_n3917
* NET  7163 = abc_29733_new_n3915
* NET  7164 = abc_29733_new_n3914
* NET  7165 = abc_29733_new_n3913
* NET  7166 = abc_29733_new_n3912
* NET  7167 = abc_29733_new_n3911
* NET  7168 = abc_29733_new_n3910
* NET  7169 = abc_29733_new_n3909
* NET  7170 = abc_29733_new_n3908
* NET  7171 = abc_29733_new_n3907
* NET  7172 = abc_29733_new_n3906
* NET  7173 = abc_29733_new_n3905
* NET  7174 = abc_29733_new_n3904
* NET  7175 = abc_29733_new_n3903
* NET  7176 = abc_29733_new_n3902
* NET  7177 = abc_29733_new_n3901
* NET  7178 = abc_29733_new_n3900
* NET  7179 = abc_29733_new_n3899
* NET  7180 = abc_29733_new_n3898
* NET  7181 = abc_29733_new_n3897
* NET  7182 = abc_29733_new_n3896
* NET  7183 = abc_29733_new_n3895
* NET  7184 = abc_29733_new_n3894
* NET  7185 = abc_29733_new_n3893
* NET  7186 = abc_29733_new_n3892
* NET  7187 = abc_29733_new_n3891
* NET  7188 = abc_29733_new_n3890
* NET  7189 = abc_29733_new_n3889
* NET  7190 = abc_29733_new_n3888
* NET  7191 = abc_29733_new_n3887
* NET  7192 = abc_29733_new_n3886
* NET  7193 = abc_29733_new_n3885
* NET  7194 = abc_29733_new_n3884
* NET  7195 = abc_29733_new_n3883
* NET  7196 = abc_29733_new_n3882
* NET  7197 = abc_29733_new_n3881
* NET  7198 = abc_29733_new_n3880
* NET  7199 = abc_29733_new_n3879
* NET  7200 = abc_29733_new_n3878
* NET  7201 = abc_29733_new_n3877
* NET  7202 = abc_29733_new_n3876
* NET  7203 = abc_29733_new_n3875
* NET  7204 = abc_29733_new_n3874
* NET  7205 = abc_29733_new_n3873
* NET  7206 = abc_29733_new_n3872
* NET  7207 = abc_29733_new_n3871
* NET  7208 = abc_29733_new_n3870
* NET  7209 = abc_29733_new_n3869
* NET  7210 = abc_29733_new_n3868
* NET  7211 = abc_29733_new_n3867
* NET  7212 = abc_29733_new_n3866
* NET  7213 = abc_29733_new_n3865
* NET  7214 = abc_29733_new_n3864
* NET  7215 = abc_29733_new_n3863
* NET  7216 = abc_29733_new_n3862
* NET  7217 = abc_29733_new_n3861
* NET  7218 = abc_29733_new_n3860
* NET  7219 = abc_29733_new_n3859
* NET  7220 = abc_29733_new_n3858
* NET  7221 = abc_29733_new_n3857
* NET  7222 = abc_29733_new_n3856
* NET  7223 = abc_29733_new_n3855
* NET  7224 = abc_29733_new_n3854
* NET  7225 = abc_29733_new_n3853
* NET  7226 = abc_29733_new_n3852
* NET  7227 = abc_29733_new_n3851
* NET  7228 = abc_29733_new_n3850
* NET  7229 = abc_29733_new_n3849
* NET  7230 = abc_29733_new_n3848
* NET  7231 = abc_29733_new_n3847
* NET  7232 = abc_29733_new_n3846
* NET  7233 = abc_29733_new_n3845
* NET  7234 = abc_29733_new_n3844
* NET  7235 = abc_29733_new_n3843
* NET  7236 = abc_29733_new_n3842
* NET  7237 = abc_29733_new_n3841
* NET  7238 = abc_29733_new_n3840
* NET  7239 = abc_29733_new_n3839
* NET  7240 = abc_29733_new_n3838
* NET  7241 = abc_29733_new_n3837
* NET  7242 = abc_29733_new_n3836
* NET  7243 = abc_29733_new_n3835
* NET  7244 = abc_29733_new_n3834
* NET  7245 = abc_29733_new_n3833
* NET  7246 = abc_29733_new_n3832
* NET  7247 = abc_29733_new_n3831
* NET  7248 = abc_29733_new_n3830
* NET  7249 = abc_29733_new_n3829
* NET  7250 = abc_29733_new_n3828
* NET  7251 = abc_29733_new_n3827
* NET  7252 = abc_29733_new_n3826
* NET  7253 = abc_29733_new_n3825
* NET  7254 = abc_29733_new_n3824
* NET  7255 = abc_29733_new_n3823
* NET  7256 = abc_29733_new_n3822
* NET  7257 = abc_29733_new_n3821
* NET  7258 = abc_29733_new_n3820
* NET  7259 = abc_29733_new_n3819
* NET  7260 = abc_29733_new_n3818
* NET  7261 = abc_29733_new_n3817
* NET  7262 = abc_29733_new_n3816
* NET  7263 = abc_29733_new_n3815
* NET  7264 = abc_29733_new_n3814
* NET  7265 = abc_29733_new_n3813
* NET  7266 = abc_29733_new_n3812
* NET  7267 = abc_29733_new_n3811
* NET  7268 = abc_29733_new_n3810
* NET  7269 = abc_29733_new_n3809
* NET  7270 = abc_29733_new_n3808
* NET  7271 = abc_29733_new_n3807
* NET  7272 = abc_29733_new_n3806
* NET  7273 = abc_29733_new_n3805
* NET  7274 = abc_29733_new_n3804
* NET  7275 = abc_29733_new_n3803
* NET  7276 = abc_29733_new_n3802
* NET  7277 = abc_29733_new_n3801
* NET  7278 = abc_29733_new_n3800
* NET  7279 = abc_29733_new_n3799
* NET  7280 = abc_29733_new_n3798
* NET  7281 = abc_29733_new_n3797
* NET  7282 = abc_29733_new_n3796
* NET  7283 = abc_29733_new_n3795
* NET  7284 = abc_29733_new_n3794
* NET  7285 = abc_29733_new_n3793
* NET  7286 = abc_29733_new_n3792
* NET  7287 = abc_29733_new_n3791
* NET  7288 = abc_29733_new_n3790
* NET  7289 = abc_29733_new_n3789
* NET  7290 = abc_29733_new_n3788
* NET  7291 = abc_29733_new_n3787
* NET  7292 = abc_29733_new_n3786
* NET  7293 = abc_29733_new_n3785
* NET  7294 = abc_29733_new_n3784
* NET  7295 = abc_29733_new_n3783
* NET  7296 = abc_29733_new_n3782
* NET  7297 = abc_29733_new_n3781
* NET  7298 = abc_29733_new_n3780
* NET  7299 = abc_29733_new_n3779
* NET  7300 = abc_29733_new_n3778
* NET  7301 = abc_29733_new_n3777
* NET  7302 = abc_29733_new_n3776
* NET  7303 = abc_29733_new_n3775
* NET  7304 = abc_29733_new_n3774
* NET  7305 = abc_29733_new_n3773
* NET  7306 = abc_29733_new_n3772
* NET  7307 = abc_29733_new_n3771
* NET  7308 = abc_29733_new_n3770
* NET  7309 = abc_29733_new_n3769
* NET  7310 = abc_29733_new_n3768
* NET  7311 = abc_29733_new_n3767
* NET  7312 = abc_29733_new_n3766
* NET  7313 = abc_29733_new_n3765
* NET  7314 = abc_29733_new_n3764
* NET  7315 = abc_29733_new_n3763
* NET  7316 = abc_29733_new_n3762
* NET  7317 = abc_29733_new_n3761
* NET  7318 = abc_29733_new_n3760
* NET  7319 = abc_29733_new_n3759
* NET  7320 = abc_29733_new_n3758
* NET  7321 = abc_29733_new_n3757
* NET  7322 = abc_29733_new_n3756
* NET  7323 = abc_29733_new_n3755
* NET  7324 = abc_29733_new_n3754
* NET  7325 = abc_29733_new_n3753
* NET  7326 = abc_29733_new_n3752
* NET  7327 = abc_29733_new_n3751
* NET  7328 = abc_29733_new_n3750
* NET  7329 = abc_29733_new_n3749
* NET  7330 = abc_29733_new_n3748
* NET  7331 = abc_29733_new_n3747
* NET  7332 = abc_29733_new_n3746
* NET  7333 = abc_29733_new_n3745
* NET  7334 = abc_29733_new_n3744
* NET  7335 = abc_29733_new_n3743
* NET  7336 = abc_29733_new_n3742
* NET  7337 = abc_29733_new_n3741
* NET  7338 = abc_29733_new_n3740
* NET  7339 = abc_29733_new_n3739
* NET  7340 = abc_29733_new_n3738
* NET  7341 = abc_29733_new_n3737
* NET  7342 = abc_29733_new_n3736
* NET  7343 = abc_29733_new_n3735
* NET  7344 = abc_29733_new_n3734
* NET  7345 = abc_29733_new_n3733
* NET  7346 = abc_29733_new_n3732
* NET  7347 = abc_29733_new_n3731
* NET  7348 = abc_29733_new_n3730
* NET  7349 = abc_29733_new_n3729
* NET  7350 = abc_29733_new_n3728
* NET  7351 = abc_29733_new_n3727
* NET  7352 = abc_29733_new_n3726
* NET  7353 = abc_29733_new_n3725
* NET  7354 = abc_29733_new_n3724
* NET  7355 = abc_29733_new_n3723
* NET  7356 = abc_29733_new_n3722
* NET  7357 = abc_29733_new_n3721
* NET  7358 = abc_29733_new_n3720
* NET  7359 = abc_29733_new_n3719
* NET  7360 = abc_29733_new_n3718
* NET  7361 = abc_29733_new_n3717
* NET  7362 = abc_29733_new_n3716
* NET  7363 = abc_29733_new_n3715
* NET  7364 = abc_29733_new_n3714
* NET  7365 = abc_29733_new_n3713
* NET  7366 = abc_29733_new_n3712
* NET  7367 = abc_29733_new_n3711
* NET  7368 = abc_29733_new_n3710
* NET  7369 = abc_29733_new_n3709
* NET  7370 = abc_29733_new_n3708
* NET  7371 = abc_29733_new_n3707
* NET  7372 = abc_29733_new_n3706
* NET  7373 = abc_29733_new_n3705
* NET  7374 = abc_29733_new_n3704
* NET  7375 = abc_29733_new_n3703
* NET  7376 = abc_29733_new_n3702
* NET  7377 = abc_29733_new_n3701
* NET  7378 = abc_29733_new_n3700
* NET  7379 = abc_29733_new_n3699
* NET  7380 = abc_29733_new_n3698
* NET  7381 = abc_29733_new_n3697
* NET  7382 = abc_29733_new_n3696
* NET  7383 = abc_29733_new_n3695
* NET  7384 = abc_29733_new_n3694
* NET  7385 = abc_29733_new_n3693
* NET  7386 = abc_29733_new_n3692
* NET  7387 = abc_29733_new_n3691
* NET  7388 = abc_29733_new_n3690
* NET  7389 = abc_29733_new_n3689
* NET  7390 = abc_29733_new_n3688
* NET  7391 = abc_29733_new_n3687
* NET  7392 = abc_29733_new_n3686
* NET  7393 = abc_29733_new_n3685
* NET  7394 = abc_29733_new_n3684
* NET  7395 = abc_29733_new_n3683
* NET  7396 = abc_29733_new_n3682
* NET  7397 = abc_29733_new_n3681
* NET  7398 = abc_29733_new_n3680
* NET  7399 = abc_29733_new_n3679
* NET  7400 = abc_29733_new_n3678
* NET  7401 = abc_29733_new_n3677
* NET  7402 = abc_29733_new_n3676
* NET  7403 = abc_29733_new_n3675
* NET  7404 = abc_29733_new_n3674
* NET  7405 = abc_29733_new_n3673
* NET  7406 = abc_29733_new_n3672
* NET  7407 = abc_29733_new_n3671
* NET  7408 = abc_29733_new_n3670
* NET  7409 = abc_29733_new_n3669
* NET  7410 = abc_29733_new_n3668
* NET  7411 = abc_29733_new_n3667
* NET  7412 = abc_29733_new_n3666
* NET  7413 = abc_29733_new_n3665
* NET  7414 = abc_29733_new_n3664
* NET  7415 = abc_29733_new_n3663
* NET  7416 = abc_29733_new_n3662
* NET  7417 = abc_29733_new_n3661
* NET  7418 = abc_29733_new_n3660
* NET  7419 = abc_29733_new_n3659
* NET  7420 = abc_29733_new_n3658
* NET  7421 = abc_29733_new_n3657
* NET  7422 = abc_29733_new_n3656
* NET  7423 = abc_29733_new_n3655
* NET  7424 = abc_29733_new_n3654
* NET  7425 = abc_29733_new_n3653
* NET  7426 = abc_29733_new_n3652
* NET  7427 = abc_29733_new_n3651
* NET  7428 = abc_29733_new_n3650
* NET  7429 = abc_29733_new_n3649
* NET  7430 = abc_29733_new_n3648
* NET  7431 = abc_29733_new_n3647
* NET  7432 = abc_29733_new_n3646
* NET  7433 = abc_29733_new_n3645
* NET  7434 = abc_29733_new_n3644
* NET  7435 = abc_29733_new_n3643
* NET  7436 = abc_29733_new_n3642
* NET  7437 = abc_29733_new_n3641
* NET  7438 = abc_29733_new_n3640
* NET  7439 = abc_29733_new_n3639
* NET  7440 = abc_29733_new_n3638
* NET  7441 = abc_29733_new_n3637
* NET  7442 = abc_29733_new_n3636
* NET  7443 = abc_29733_new_n3635
* NET  7444 = abc_29733_new_n3634
* NET  7445 = abc_29733_new_n3633
* NET  7446 = abc_29733_new_n3632
* NET  7447 = abc_29733_new_n3631
* NET  7448 = abc_29733_new_n3630
* NET  7449 = abc_29733_new_n3629
* NET  7450 = abc_29733_new_n3628
* NET  7451 = abc_29733_new_n3627
* NET  7452 = abc_29733_new_n3626
* NET  7453 = abc_29733_new_n3625
* NET  7454 = abc_29733_new_n3624
* NET  7455 = abc_29733_new_n3623
* NET  7456 = abc_29733_new_n3622
* NET  7457 = abc_29733_new_n3621
* NET  7458 = abc_29733_new_n3620
* NET  7459 = abc_29733_new_n3619
* NET  7460 = abc_29733_new_n3618
* NET  7461 = abc_29733_new_n3617
* NET  7462 = abc_29733_new_n3616
* NET  7463 = abc_29733_new_n3615
* NET  7464 = abc_29733_new_n3614
* NET  7465 = abc_29733_new_n3613
* NET  7466 = abc_29733_new_n3612
* NET  7467 = abc_29733_new_n3611
* NET  7468 = abc_29733_new_n3610
* NET  7469 = abc_29733_new_n3609
* NET  7470 = abc_29733_new_n3608
* NET  7471 = abc_29733_new_n3607
* NET  7472 = abc_29733_new_n3606
* NET  7473 = abc_29733_new_n3605
* NET  7474 = abc_29733_new_n3604
* NET  7475 = abc_29733_new_n3603
* NET  7476 = abc_29733_new_n3602
* NET  7477 = abc_29733_new_n3601
* NET  7478 = abc_29733_new_n3600
* NET  7479 = abc_29733_new_n3599
* NET  7480 = abc_29733_new_n3598
* NET  7481 = abc_29733_new_n3597
* NET  7482 = abc_29733_new_n3596
* NET  7483 = abc_29733_new_n3595
* NET  7484 = abc_29733_new_n3594
* NET  7485 = abc_29733_new_n3593
* NET  7486 = abc_29733_new_n3592
* NET  7487 = abc_29733_new_n3591
* NET  7488 = abc_29733_new_n3590
* NET  7489 = abc_29733_new_n3589
* NET  7490 = abc_29733_new_n3588
* NET  7491 = abc_29733_new_n3587
* NET  7492 = abc_29733_new_n3586
* NET  7493 = abc_29733_new_n3585
* NET  7494 = abc_29733_new_n3584
* NET  7495 = abc_29733_new_n3583
* NET  7496 = abc_29733_new_n3582
* NET  7497 = abc_29733_new_n3581
* NET  7498 = abc_29733_new_n3580
* NET  7499 = abc_29733_new_n3579
* NET  7500 = abc_29733_new_n3578
* NET  7501 = abc_29733_new_n3577
* NET  7502 = abc_29733_new_n3576
* NET  7503 = abc_29733_new_n3575
* NET  7504 = abc_29733_new_n3574
* NET  7505 = abc_29733_new_n3573
* NET  7506 = abc_29733_new_n3572
* NET  7507 = abc_29733_new_n3571
* NET  7508 = abc_29733_new_n3570
* NET  7509 = abc_29733_new_n3569
* NET  7510 = abc_29733_new_n3568
* NET  7511 = abc_29733_new_n3567
* NET  7512 = abc_29733_new_n3566
* NET  7513 = abc_29733_new_n3565
* NET  7514 = abc_29733_new_n3564
* NET  7515 = abc_29733_new_n3563
* NET  7516 = abc_29733_new_n3562
* NET  7517 = abc_29733_new_n3561
* NET  7518 = abc_29733_new_n3560
* NET  7519 = abc_29733_new_n3559
* NET  7520 = abc_29733_new_n3558
* NET  7521 = abc_29733_new_n3557
* NET  7522 = abc_29733_new_n3556
* NET  7523 = abc_29733_new_n3555
* NET  7524 = abc_29733_new_n3554
* NET  7525 = abc_29733_new_n3553
* NET  7526 = abc_29733_new_n3552
* NET  7527 = abc_29733_new_n3551
* NET  7528 = abc_29733_new_n3550
* NET  7529 = abc_29733_new_n3549
* NET  7530 = abc_29733_new_n3548
* NET  7531 = abc_29733_new_n3547
* NET  7532 = abc_29733_new_n3546
* NET  7533 = abc_29733_new_n3545
* NET  7534 = abc_29733_new_n3544
* NET  7535 = abc_29733_new_n3543
* NET  7536 = abc_29733_new_n3542
* NET  7537 = abc_29733_new_n3541
* NET  7538 = abc_29733_new_n3540
* NET  7539 = abc_29733_new_n3539
* NET  7540 = abc_29733_new_n3538
* NET  7541 = abc_29733_new_n3537
* NET  7542 = abc_29733_new_n3536
* NET  7543 = abc_29733_new_n3535
* NET  7544 = abc_29733_new_n3534
* NET  7545 = abc_29733_new_n3533
* NET  7546 = abc_29733_new_n3532
* NET  7547 = abc_29733_new_n3531
* NET  7548 = abc_29733_new_n3530
* NET  7549 = abc_29733_new_n3529
* NET  7550 = abc_29733_new_n3528
* NET  7551 = abc_29733_new_n3527
* NET  7552 = abc_29733_new_n3526
* NET  7553 = abc_29733_new_n3525
* NET  7554 = abc_29733_new_n3524
* NET  7555 = abc_29733_new_n3523
* NET  7556 = abc_29733_new_n3522
* NET  7557 = abc_29733_new_n3521
* NET  7558 = abc_29733_new_n3520
* NET  7559 = abc_29733_new_n3519
* NET  7560 = abc_29733_new_n3518
* NET  7561 = abc_29733_new_n3517
* NET  7562 = abc_29733_new_n3516
* NET  7563 = abc_29733_new_n3515
* NET  7564 = abc_29733_new_n3514
* NET  7565 = abc_29733_new_n3513
* NET  7566 = abc_29733_new_n3512
* NET  7567 = abc_29733_new_n3511
* NET  7568 = abc_29733_new_n3510
* NET  7569 = abc_29733_new_n3509
* NET  7570 = abc_29733_new_n3508
* NET  7571 = abc_29733_new_n3507
* NET  7572 = abc_29733_new_n3506
* NET  7573 = abc_29733_new_n3505
* NET  7574 = abc_29733_new_n3504
* NET  7575 = abc_29733_new_n3503
* NET  7576 = abc_29733_new_n3502
* NET  7577 = abc_29733_new_n3501
* NET  7578 = abc_29733_new_n3500
* NET  7579 = abc_29733_new_n3499
* NET  7580 = abc_29733_new_n3498
* NET  7581 = abc_29733_new_n3497
* NET  7582 = abc_29733_new_n3496
* NET  7583 = abc_29733_new_n3495
* NET  7584 = abc_29733_new_n3494
* NET  7585 = abc_29733_new_n3493
* NET  7586 = abc_29733_new_n3492
* NET  7587 = abc_29733_new_n3491
* NET  7588 = abc_29733_new_n3490
* NET  7589 = abc_29733_new_n3489
* NET  7590 = abc_29733_new_n3488
* NET  7591 = abc_29733_new_n3487
* NET  7592 = abc_29733_new_n3486
* NET  7593 = abc_29733_new_n3485
* NET  7594 = abc_29733_new_n3484
* NET  7595 = abc_29733_new_n3483
* NET  7596 = abc_29733_new_n3482
* NET  7597 = abc_29733_new_n3481
* NET  7598 = abc_29733_new_n3480
* NET  7599 = abc_29733_new_n3479
* NET  7600 = abc_29733_new_n3478
* NET  7601 = abc_29733_new_n3477
* NET  7602 = abc_29733_new_n3476
* NET  7603 = abc_29733_new_n3475
* NET  7604 = abc_29733_new_n3474
* NET  7605 = abc_29733_new_n3473
* NET  7606 = abc_29733_new_n3472
* NET  7607 = abc_29733_new_n3471
* NET  7608 = abc_29733_new_n3470
* NET  7609 = abc_29733_new_n3469
* NET  7610 = abc_29733_new_n3468
* NET  7611 = abc_29733_new_n3467
* NET  7612 = abc_29733_new_n3466
* NET  7613 = abc_29733_new_n3465
* NET  7614 = abc_29733_new_n3464
* NET  7615 = abc_29733_new_n3463
* NET  7616 = abc_29733_new_n3462
* NET  7617 = abc_29733_new_n3461
* NET  7618 = abc_29733_new_n3460
* NET  7619 = abc_29733_new_n3459
* NET  7620 = abc_29733_new_n3458
* NET  7621 = abc_29733_new_n3457
* NET  7622 = abc_29733_new_n3456
* NET  7623 = abc_29733_new_n3455
* NET  7624 = abc_29733_new_n3454
* NET  7625 = abc_29733_new_n3453
* NET  7626 = abc_29733_new_n3452
* NET  7627 = abc_29733_new_n3451
* NET  7628 = abc_29733_new_n3450
* NET  7629 = abc_29733_new_n3449
* NET  7630 = abc_29733_new_n3448
* NET  7631 = abc_29733_new_n3447
* NET  7632 = abc_29733_new_n3446
* NET  7633 = abc_29733_new_n3445
* NET  7634 = abc_29733_new_n3444
* NET  7635 = abc_29733_new_n3443
* NET  7636 = abc_29733_new_n3442
* NET  7637 = abc_29733_new_n3441
* NET  7638 = abc_29733_new_n3440
* NET  7639 = abc_29733_new_n3439
* NET  7640 = abc_29733_new_n3438
* NET  7641 = abc_29733_new_n3437
* NET  7642 = abc_29733_new_n3436
* NET  7643 = abc_29733_new_n3435
* NET  7644 = abc_29733_new_n3434
* NET  7645 = abc_29733_new_n3433
* NET  7646 = abc_29733_new_n3432
* NET  7647 = abc_29733_new_n3431
* NET  7648 = abc_29733_new_n3430
* NET  7649 = abc_29733_new_n3429
* NET  7650 = abc_29733_new_n3428
* NET  7651 = abc_29733_new_n3427
* NET  7652 = abc_29733_new_n3426
* NET  7653 = abc_29733_new_n3425
* NET  7654 = abc_29733_new_n3424
* NET  7655 = abc_29733_new_n3423
* NET  7656 = abc_29733_new_n3422
* NET  7657 = abc_29733_new_n3421
* NET  7658 = abc_29733_new_n3420
* NET  7659 = abc_29733_new_n3419
* NET  7660 = abc_29733_new_n3418
* NET  7661 = abc_29733_new_n3417
* NET  7662 = abc_29733_new_n3416
* NET  7663 = abc_29733_new_n3415
* NET  7664 = abc_29733_new_n3414
* NET  7665 = abc_29733_new_n3413
* NET  7666 = abc_29733_new_n3412
* NET  7667 = abc_29733_new_n3411
* NET  7668 = abc_29733_new_n3410
* NET  7669 = abc_29733_new_n3409
* NET  7670 = abc_29733_new_n3408
* NET  7671 = abc_29733_new_n3407
* NET  7672 = abc_29733_new_n3406
* NET  7673 = abc_29733_new_n3405
* NET  7674 = abc_29733_new_n3404
* NET  7675 = abc_29733_new_n3403
* NET  7676 = abc_29733_new_n3402
* NET  7677 = abc_29733_new_n3401
* NET  7678 = abc_29733_new_n3400
* NET  7679 = abc_29733_new_n3399
* NET  7680 = abc_29733_new_n3398
* NET  7681 = abc_29733_new_n3397
* NET  7682 = abc_29733_new_n3396
* NET  7683 = abc_29733_new_n3395
* NET  7684 = abc_29733_new_n3394
* NET  7685 = abc_29733_new_n3393
* NET  7686 = abc_29733_new_n3392
* NET  7687 = abc_29733_new_n3391
* NET  7688 = abc_29733_new_n3390
* NET  7689 = abc_29733_new_n3389
* NET  7690 = abc_29733_new_n3388
* NET  7691 = abc_29733_new_n3387
* NET  7692 = abc_29733_new_n3386
* NET  7693 = abc_29733_new_n3385
* NET  7694 = abc_29733_new_n3384
* NET  7695 = abc_29733_new_n3383
* NET  7696 = abc_29733_new_n3382
* NET  7697 = abc_29733_new_n3381
* NET  7698 = abc_29733_new_n3380
* NET  7699 = abc_29733_new_n3379
* NET  7700 = abc_29733_new_n3378
* NET  7701 = abc_29733_new_n3377
* NET  7702 = abc_29733_new_n3376
* NET  7703 = abc_29733_new_n3375
* NET  7704 = abc_29733_new_n3374
* NET  7705 = abc_29733_new_n3373
* NET  7706 = abc_29733_new_n3372
* NET  7707 = abc_29733_new_n3371
* NET  7708 = abc_29733_new_n3370
* NET  7709 = abc_29733_new_n3369
* NET  7710 = abc_29733_new_n3368
* NET  7711 = abc_29733_new_n3367
* NET  7712 = abc_29733_new_n3366
* NET  7713 = abc_29733_new_n3365
* NET  7714 = abc_29733_new_n3364
* NET  7715 = abc_29733_new_n3363
* NET  7716 = abc_29733_new_n3362
* NET  7717 = abc_29733_new_n3361
* NET  7718 = abc_29733_new_n3360
* NET  7719 = abc_29733_new_n3359
* NET  7720 = abc_29733_new_n3358
* NET  7721 = abc_29733_new_n3357
* NET  7722 = abc_29733_new_n3356
* NET  7723 = abc_29733_new_n3355
* NET  7724 = abc_29733_new_n3354
* NET  7725 = abc_29733_new_n3353
* NET  7726 = abc_29733_new_n3352
* NET  7727 = abc_29733_new_n3351
* NET  7728 = abc_29733_new_n3350
* NET  7729 = abc_29733_new_n3349
* NET  7730 = abc_29733_new_n3348
* NET  7731 = abc_29733_new_n3347
* NET  7732 = abc_29733_new_n3346
* NET  7733 = abc_29733_new_n3345
* NET  7734 = abc_29733_new_n3344
* NET  7735 = abc_29733_new_n3343
* NET  7736 = abc_29733_new_n3342
* NET  7737 = abc_29733_new_n3341
* NET  7738 = abc_29733_new_n3340
* NET  7739 = abc_29733_new_n3339
* NET  7740 = abc_29733_new_n3338
* NET  7741 = abc_29733_new_n3337
* NET  7742 = abc_29733_new_n3336
* NET  7743 = abc_29733_new_n3335
* NET  7744 = abc_29733_new_n3334
* NET  7745 = abc_29733_new_n3333
* NET  7746 = abc_29733_new_n3332
* NET  7747 = abc_29733_new_n3331
* NET  7748 = abc_29733_new_n3330
* NET  7749 = abc_29733_new_n3329
* NET  7750 = abc_29733_new_n3328
* NET  7751 = abc_29733_new_n3327
* NET  7752 = abc_29733_new_n3326
* NET  7753 = abc_29733_new_n3325
* NET  7754 = abc_29733_new_n3324
* NET  7755 = abc_29733_new_n3323
* NET  7756 = abc_29733_new_n3322
* NET  7757 = abc_29733_new_n3321
* NET  7758 = abc_29733_new_n3320
* NET  7759 = abc_29733_new_n3319
* NET  7760 = abc_29733_new_n3318
* NET  7761 = abc_29733_new_n3317
* NET  7762 = abc_29733_new_n3316
* NET  7763 = abc_29733_new_n3315
* NET  7764 = abc_29733_new_n3314
* NET  7765 = abc_29733_new_n3313
* NET  7766 = abc_29733_new_n3312
* NET  7767 = abc_29733_new_n3311
* NET  7768 = abc_29733_new_n3310
* NET  7769 = abc_29733_new_n3309
* NET  7770 = abc_29733_new_n3308
* NET  7771 = abc_29733_new_n3307
* NET  7772 = abc_29733_new_n3306
* NET  7773 = abc_29733_new_n3305
* NET  7774 = abc_29733_new_n3304
* NET  7775 = abc_29733_new_n3303
* NET  7776 = abc_29733_new_n3302
* NET  7777 = abc_29733_new_n3301
* NET  7778 = abc_29733_new_n3300
* NET  7779 = abc_29733_new_n3299
* NET  7780 = abc_29733_new_n3298
* NET  7781 = abc_29733_new_n3297
* NET  7782 = abc_29733_new_n3296
* NET  7783 = abc_29733_new_n3295
* NET  7784 = abc_29733_new_n3294
* NET  7785 = abc_29733_new_n3293
* NET  7786 = abc_29733_new_n3292
* NET  7787 = abc_29733_new_n3291
* NET  7788 = abc_29733_new_n3290
* NET  7789 = abc_29733_new_n3289
* NET  7790 = abc_29733_new_n3288
* NET  7791 = abc_29733_new_n3287
* NET  7792 = abc_29733_new_n11543
* NET  7793 = abc_29733_new_n11542
* NET  7794 = abc_29733_new_n11541
* NET  7795 = abc_29733_new_n11540
* NET  7796 = abc_29733_new_n11539
* NET  7797 = abc_29733_new_n11506
* NET  7798 = abc_29733_new_n11505
* NET  7799 = abc_29733_new_n11472
* NET  7800 = abc_29733_new_n11471
* NET  7801 = abc_29733_new_n11438
* NET  7802 = abc_29733_new_n11437
* NET  7803 = abc_29733_new_n11404
* NET  7804 = abc_29733_new_n11403
* NET  7805 = abc_29733_new_n11370
* NET  7806 = abc_29733_new_n11369
* NET  7807 = abc_29733_new_n11336
* NET  7808 = abc_29733_new_n11335
* NET  7809 = abc_29733_new_n11302
* NET  7810 = abc_29733_new_n11301
* NET  7811 = abc_29733_new_n11268
* NET  7812 = abc_29733_new_n11267
* NET  7813 = abc_29733_new_n11234
* NET  7814 = abc_29733_new_n11233
* NET  7815 = abc_29733_new_n11200
* NET  7816 = abc_29733_new_n11199
* NET  7817 = abc_29733_new_n11166
* NET  7818 = abc_29733_new_n11165
* NET  7819 = abc_29733_new_n11132
* NET  7820 = abc_29733_new_n11131
* NET  7821 = abc_29733_new_n11098
* NET  7822 = abc_29733_new_n11097
* NET  7823 = abc_29733_new_n11095
* NET  7824 = abc_29733_new_n11093
* NET  7825 = abc_29733_new_n11060
* NET  7826 = abc_29733_new_n11059
* NET  7827 = abc_29733_new_n11026
* NET  7828 = abc_29733_new_n11025
* NET  7829 = abc_29733_new_n10992
* NET  7830 = abc_29733_new_n10991
* NET  7831 = abc_29733_new_n10989
* NET  7832 = abc_29733_new_n10988
* NET  7833 = abc_29733_new_n10987
* NET  7834 = abc_29733_new_n10985
* NET  7835 = abc_29733_new_n10984
* NET  7836 = abc_29733_new_n10983
* NET  7837 = abc_29733_new_n10982
* NET  7838 = abc_29733_new_n10981
* NET  7839 = abc_29733_new_n10979
* NET  7840 = abc_29733_new_n10978
* NET  7841 = abc_29733_new_n10977
* NET  7842 = abc_29733_new_n10976
* NET  7843 = abc_29733_new_n10974
* NET  7844 = abc_29733_new_n10973
* NET  7845 = abc_29733_new_n10972
* NET  7846 = abc_29733_new_n10971
* NET  7847 = abc_29733_new_n10969
* NET  7848 = abc_29733_new_n10968
* NET  7849 = abc_29733_new_n10967
* NET  7850 = abc_29733_new_n10966
* NET  7851 = abc_29733_new_n10964
* NET  7852 = abc_29733_new_n10963
* NET  7853 = abc_29733_new_n10962
* NET  7854 = abc_29733_new_n10961
* NET  7855 = abc_29733_new_n10959
* NET  7856 = abc_29733_new_n10958
* NET  7857 = abc_29733_new_n10957
* NET  7858 = abc_29733_new_n10956
* NET  7859 = abc_29733_new_n10954
* NET  7860 = abc_29733_new_n10953
* NET  7861 = abc_29733_new_n10952
* NET  7862 = abc_29733_new_n10951
* NET  7863 = abc_29733_new_n10949
* NET  7864 = abc_29733_new_n10948
* NET  7865 = abc_29733_new_n10947
* NET  7866 = abc_29733_new_n10946
* NET  7867 = abc_29733_new_n10944
* NET  7868 = abc_29733_new_n10943
* NET  7869 = abc_29733_new_n10942
* NET  7870 = abc_29733_new_n10941
* NET  7871 = abc_29733_new_n10939
* NET  7872 = abc_29733_new_n10938
* NET  7873 = abc_29733_new_n10937
* NET  7874 = abc_29733_new_n10936
* NET  7875 = abc_29733_new_n10935
* NET  7876 = abc_29733_new_n10934
* NET  7877 = abc_29733_new_n10932
* NET  7878 = abc_29733_new_n10931
* NET  7879 = abc_29733_new_n10930
* NET  7880 = abc_29733_new_n10929
* NET  7881 = abc_29733_new_n10928
* NET  7882 = abc_29733_new_n10926
* NET  7883 = abc_29733_new_n10925
* NET  7884 = abc_29733_new_n10924
* NET  7885 = abc_29733_new_n10923
* NET  7886 = abc_29733_new_n10922
* NET  7887 = abc_29733_new_n10920
* NET  7888 = abc_29733_new_n10919
* NET  7889 = abc_29733_new_n10918
* NET  7890 = abc_29733_new_n10917
* NET  7891 = abc_29733_new_n10916
* NET  7892 = abc_29733_new_n10914
* NET  7893 = abc_29733_new_n10913
* NET  7894 = abc_29733_new_n10912
* NET  7895 = abc_29733_new_n10911
* NET  7896 = abc_29733_new_n10910
* NET  7897 = abc_29733_new_n10908
* NET  7898 = abc_29733_new_n10907
* NET  7899 = abc_29733_new_n10906
* NET  7900 = abc_29733_new_n10905
* NET  7901 = abc_29733_new_n10904
* NET  7902 = abc_29733_new_n10902
* NET  7903 = abc_29733_new_n10901
* NET  7904 = abc_29733_new_n10900
* NET  7905 = abc_29733_new_n10899
* NET  7906 = abc_29733_new_n10898
* NET  7907 = abc_29733_new_n10896
* NET  7908 = abc_29733_new_n10895
* NET  7909 = abc_29733_new_n10894
* NET  7910 = abc_29733_new_n10893
* NET  7911 = abc_29733_new_n10892
* NET  7912 = abc_29733_new_n10890
* NET  7913 = abc_29733_new_n10889
* NET  7914 = abc_29733_new_n10888
* NET  7915 = abc_29733_new_n10887
* NET  7916 = abc_29733_new_n10886
* NET  7917 = abc_29733_new_n10884
* NET  7918 = abc_29733_new_n10883
* NET  7919 = abc_29733_new_n10882
* NET  7920 = abc_29733_new_n10880
* NET  7921 = abc_29733_new_n10879
* NET  7922 = abc_29733_new_n10878
* NET  7923 = abc_29733_new_n10876
* NET  7924 = abc_29733_new_n10875
* NET  7925 = abc_29733_new_n10874
* NET  7926 = abc_29733_new_n10872
* NET  7927 = abc_29733_new_n10871
* NET  7928 = abc_29733_new_n10870
* NET  7929 = abc_29733_new_n10868
* NET  7930 = abc_29733_new_n10867
* NET  7931 = abc_29733_new_n10866
* NET  7932 = abc_29733_new_n10864
* NET  7933 = abc_29733_new_n10863
* NET  7934 = abc_29733_new_n10862
* NET  7935 = abc_29733_new_n10860
* NET  7936 = abc_29733_new_n10859
* NET  7937 = abc_29733_new_n10858
* NET  7938 = abc_29733_new_n10856
* NET  7939 = abc_29733_new_n10855
* NET  7940 = abc_29733_new_n10854
* NET  7941 = abc_29733_new_n10852
* NET  7942 = abc_29733_new_n10851
* NET  7943 = abc_29733_new_n10850
* NET  7944 = abc_29733_new_n10848
* NET  7945 = abc_29733_new_n10847
* NET  7946 = abc_29733_new_n10846
* NET  7947 = abc_29733_new_n10844
* NET  7948 = abc_29733_new_n10843
* NET  7949 = abc_29733_new_n10842
* NET  7950 = abc_29733_new_n10840
* NET  7951 = abc_29733_new_n10839
* NET  7952 = abc_29733_new_n10838
* NET  7953 = abc_29733_new_n10837
* NET  7954 = abc_29733_new_n10836
* NET  7955 = abc_29733_new_n10835
* NET  7956 = abc_29733_new_n10834
* NET  7957 = abc_29733_new_n10833
* NET  7958 = abc_29733_new_n10832
* NET  7959 = abc_29733_new_n10831
* NET  7960 = abc_29733_new_n10829
* NET  7961 = abc_29733_new_n10828
* NET  7962 = abc_29733_new_n10826
* NET  7963 = abc_29733_new_n10825
* NET  7964 = abc_29733_new_n10823
* NET  7965 = abc_29733_new_n10822
* NET  7966 = abc_29733_new_n10820
* NET  7967 = abc_29733_new_n10819
* NET  7968 = abc_29733_new_n10817
* NET  7969 = abc_29733_new_n10816
* NET  7970 = abc_29733_new_n10815
* NET  7971 = abc_29733_new_n10813
* NET  7972 = abc_29733_new_n10812
* NET  7973 = abc_29733_new_n10811
* NET  7974 = abc_29733_new_n10809
* NET  7975 = abc_29733_new_n10808
* NET  7976 = abc_29733_new_n10807
* NET  7977 = abc_29733_new_n10805
* NET  7978 = abc_29733_new_n10804
* NET  7979 = abc_29733_new_n10803
* NET  7980 = abc_29733_new_n10801
* NET  7981 = abc_29733_new_n10800
* NET  7982 = abc_29733_new_n10799
* NET  7983 = abc_29733_new_n10798
* NET  7984 = abc_29733_new_n10764
* NET  7985 = abc_29733_new_n10763
* NET  7986 = abc_29733_new_n10762
* NET  7987 = abc_29733_new_n10760
* NET  7988 = abc_29733_new_n10759
* NET  7989 = abc_29733_new_n10758
* NET  7990 = abc_29733_new_n10757
* NET  7991 = abc_29733_new_n10756
* NET  7992 = abc_29733_new_n10755
* NET  7993 = abc_29733_new_n10754
* NET  7994 = abc_29733_new_n10753
* NET  7995 = abc_29733_new_n10752
* NET  7996 = abc_29733_new_n10751
* NET  7997 = abc_29733_new_n10749
* NET  7998 = abc_29733_new_n10747
* NET  7999 = abc_29733_new_n10745
* NET  8000 = abc_29733_new_n10743
* NET  8001 = abc_29733_new_n10741
* NET  8002 = abc_29733_new_n10739
* NET  8003 = abc_29733_new_n10737
* NET  8004 = abc_29733_new_n10735
* NET  8005 = abc_29733_new_n10734
* NET  8006 = abc_29733_new_n10733
* NET  8007 = abc_29733_new_n10731
* NET  8008 = abc_29733_new_n10730
* NET  8009 = abc_29733_new_n10729
* NET  8010 = abc_29733_new_n10728
* NET  8011 = abc_29733_new_n10726
* NET  8012 = abc_29733_new_n10725
* NET  8013 = abc_29733_new_n10724
* NET  8014 = abc_29733_new_n10723
* NET  8015 = abc_29733_new_n10721
* NET  8016 = abc_29733_new_n10720
* NET  8017 = abc_29733_new_n10719
* NET  8018 = abc_29733_new_n10718
* NET  8019 = abc_29733_new_n10717
* NET  8020 = abc_29733_new_n10703
* NET  8021 = abc_29733_new_n10687
* NET  8022 = abc_29733_new_n10685
* NET  8023 = abc_29733_new_n10684
* NET  8024 = abc_29733_new_n10683
* NET  8025 = abc_29733_new_n10681
* NET  8026 = abc_29733_new_n10680
* NET  8027 = abc_29733_new_n10679
* NET  8028 = abc_29733_new_n10677
* NET  8029 = abc_29733_new_n10676
* NET  8030 = abc_29733_new_n10675
* NET  8031 = abc_29733_new_n10674
* NET  8032 = abc_29733_new_n10673
* NET  8033 = abc_29733_new_n10672
* NET  8034 = abc_29733_new_n10671
* NET  8035 = abc_29733_new_n10670
* NET  8036 = abc_29733_new_n10669
* NET  8037 = abc_29733_new_n10668
* NET  8038 = abc_29733_new_n10667
* NET  8039 = abc_29733_new_n10666
* NET  8040 = abc_29733_new_n10665
* NET  8041 = abc_29733_new_n10663
* NET  8042 = abc_29733_new_n10662
* NET  8043 = abc_29733_new_n10660
* NET  8044 = abc_29733_new_n10659
* NET  8045 = abc_29733_new_n10658
* NET  8046 = abc_29733_new_n10656
* NET  8047 = abc_29733_new_n10655
* NET  8048 = abc_29733_new_n10653
* NET  8049 = abc_29733_new_n10652
* NET  8050 = abc_29733_new_n10650
* NET  8051 = abc_29733_new_n10649
* NET  8052 = abc_29733_new_n10648
* NET  8053 = abc_29733_new_n10646
* NET  8054 = abc_29733_new_n10645
* NET  8055 = abc_29733_new_n10643
* NET  8056 = abc_29733_new_n10642
* NET  8057 = abc_29733_new_n10640
* NET  8058 = abc_29733_new_n10639
* NET  8059 = abc_29733_new_n10637
* NET  8060 = abc_29733_new_n10636
* NET  8061 = abc_29733_new_n10635
* NET  8062 = abc_29733_new_n10633
* NET  8063 = abc_29733_new_n10632
* NET  8064 = abc_29733_new_n10631
* NET  8065 = abc_29733_new_n10629
* NET  8066 = abc_29733_new_n10628
* NET  8067 = abc_29733_new_n10627
* NET  8068 = abc_29733_new_n10626
* NET  8069 = abc_29733_new_n10624
* NET  8070 = abc_29733_new_n10623
* NET  8071 = abc_29733_new_n10622
* NET  8072 = abc_29733_new_n10620
* NET  8073 = abc_29733_new_n10619
* NET  8074 = abc_29733_new_n10618
* NET  8075 = abc_29733_new_n10617
* NET  8076 = abc_29733_new_n10616
* NET  8077 = abc_29733_new_n10615
* NET  8078 = abc_29733_new_n10614
* NET  8079 = abc_29733_new_n10613
* NET  8080 = abc_29733_new_n10612
* NET  8081 = abc_29733_new_n10611
* NET  8082 = abc_29733_new_n10609
* NET  8083 = abc_29733_new_n10607
* NET  8084 = abc_29733_new_n10606
* NET  8085 = abc_29733_new_n10604
* NET  8086 = abc_29733_new_n10603
* NET  8087 = abc_29733_new_n10601
* NET  8088 = abc_29733_new_n10600
* NET  8089 = abc_29733_new_n10598
* NET  8090 = abc_29733_new_n10597
* NET  8091 = abc_29733_new_n10596
* NET  8092 = abc_29733_new_n10594
* NET  8093 = abc_29733_new_n10593
* NET  8094 = abc_29733_new_n10591
* NET  8095 = abc_29733_new_n10590
* NET  8096 = abc_29733_new_n10589
* NET  8097 = abc_29733_new_n10588
* NET  8098 = abc_29733_new_n10587
* NET  8099 = abc_29733_new_n10585
* NET  8100 = abc_29733_new_n10583
* NET  8101 = abc_29733_new_n10582
* NET  8102 = abc_29733_new_n10581
* NET  8103 = abc_29733_new_n10579
* NET  8104 = abc_29733_new_n10577
* NET  8105 = abc_29733_new_n10575
* NET  8106 = abc_29733_new_n10574
* NET  8107 = abc_29733_new_n10572
* NET  8108 = abc_29733_new_n10570
* NET  8109 = abc_29733_new_n10569
* NET  8110 = abc_29733_new_n10568
* NET  8111 = abc_29733_new_n10566
* NET  8112 = abc_29733_new_n10565
* NET  8113 = abc_29733_new_n10563
* NET  8114 = abc_29733_new_n10561
* NET  8115 = abc_29733_new_n10560
* NET  8116 = abc_29733_new_n10559
* NET  8117 = abc_29733_new_n10557
* NET  8118 = abc_29733_new_n10556
* NET  8119 = abc_29733_new_n10554
* NET  8120 = abc_29733_new_n10553
* NET  8121 = abc_29733_new_n10552
* NET  8122 = abc_29733_new_n10550
* NET  8123 = abc_29733_new_n10549
* NET  8124 = abc_29733_new_n10548
* NET  8125 = abc_29733_new_n10546
* NET  8126 = abc_29733_new_n10545
* NET  8127 = abc_29733_new_n10544
* NET  8128 = abc_29733_new_n10542
* NET  8129 = abc_29733_new_n10541
* NET  8130 = abc_29733_new_n10540
* NET  8131 = abc_29733_new_n10538
* NET  8132 = abc_29733_new_n10537
* NET  8133 = abc_29733_new_n10536
* NET  8134 = abc_29733_new_n10534
* NET  8135 = abc_29733_new_n10533
* NET  8136 = abc_29733_new_n10532
* NET  8137 = abc_29733_new_n10531
* NET  8138 = abc_29733_new_n10530
* NET  8139 = abc_29733_new_n10529
* NET  8140 = abc_29733_new_n10528
* NET  8141 = abc_29733_new_n10526
* NET  8142 = abc_29733_new_n10525
* NET  8143 = abc_29733_new_n10524
* NET  8144 = abc_29733_new_n10523
* NET  8145 = abc_29733_new_n10521
* NET  8146 = abc_29733_new_n10520
* NET  8147 = abc_29733_new_n10519
* NET  8148 = abc_29733_new_n10517
* NET  8149 = abc_29733_new_n10516
* NET  8150 = abc_29733_new_n10515
* NET  8151 = abc_29733_new_n10513
* NET  8152 = abc_29733_new_n10511
* NET  8153 = abc_29733_new_n10509
* NET  8154 = abc_29733_new_n10508
* NET  8155 = abc_29733_new_n10506
* NET  8156 = abc_29733_new_n10504
* NET  8157 = abc_29733_new_n10469
* NET  8158 = abc_29733_new_n10468
* NET  8159 = abc_29733_new_n10466
* NET  8160 = abc_29733_new_n10465
* NET  8161 = abc_29733_new_n10463
* NET  8162 = abc_29733_new_n10462
* NET  8163 = abc_29733_new_n10461
* NET  8164 = abc_29733_new_n10460
* NET  8165 = abc_29733_new_n10459
* NET  8166 = abc_29733_new_n10426
* NET  8167 = abc_29733_new_n10425
* NET  8168 = abc_29733_new_n10423
* NET  8169 = abc_29733_new_n10422
* NET  8170 = abc_29733_new_n10421
* NET  8171 = abc_29733_new_n10420
* NET  8172 = abc_29733_new_n10419
* NET  8173 = abc_29733_new_n10417
* NET  8174 = abc_29733_new_n10416
* NET  8175 = abc_29733_new_n10414
* NET  8176 = abc_29733_new_n10413
* NET  8177 = abc_29733_new_n10412
* NET  8178 = abc_29733_new_n10411
* NET  8179 = abc_29733_new_n10410
* NET  8180 = abc_29733_new_n10409
* NET  8181 = abc_29733_new_n10408
* NET  8182 = abc_29733_new_n10407
* NET  8183 = abc_29733_new_n10406
* NET  8184 = abc_29733_new_n10404
* NET  8185 = abc_29733_new_n10403
* NET  8186 = abc_29733_new_n10402
* NET  8187 = abc_29733_new_n10401
* NET  8188 = abc_29733_new_n10400
* NET  8189 = abc_29733_new_n10399
* NET  8190 = abc_29733_new_n10398
* NET  8191 = abc_29733_new_n10397
* NET  8192 = abc_29733_new_n10396
* NET  8193 = abc_29733_new_n10395
* NET  8194 = abc_29733_new_n10394
* NET  8195 = abc_29733_new_n10393
* NET  8196 = abc_29733_new_n10392
* NET  8197 = abc_29733_new_n10391
* NET  8198 = abc_29733_new_n10390
* NET  8199 = abc_29733_new_n10389
* NET  8200 = abc_29733_new_n10388
* NET  8201 = abc_29733_new_n10387
* NET  8202 = abc_29733_new_n10386
* NET  8203 = abc_29733_new_n10385
* NET  8204 = abc_29733_new_n10384
* NET  8205 = abc_29733_new_n10383
* NET  8206 = abc_29733_new_n10382
* NET  8207 = abc_29733_new_n10381
* NET  8208 = abc_29733_new_n10380
* NET  8209 = abc_29733_new_n10379
* NET  8210 = abc_29733_new_n10378
* NET  8211 = abc_29733_new_n10377
* NET  8212 = abc_29733_new_n10376
* NET  8213 = abc_29733_new_n10375
* NET  8214 = abc_29733_new_n10374
* NET  8215 = abc_29733_new_n10373
* NET  8216 = abc_29733_new_n10372
* NET  8217 = abc_29733_new_n10371
* NET  8218 = abc_29733_new_n10370
* NET  8219 = abc_29733_new_n10369
* NET  8220 = abc_29733_new_n10368
* NET  8221 = abc_29733_new_n10367
* NET  8222 = abc_29733_new_n10366
* NET  8223 = abc_29733_new_n10365
* NET  8224 = abc_29733_new_n10364
* NET  8225 = abc_29733_new_n10363
* NET  8226 = abc_29733_new_n10362
* NET  8227 = abc_29733_new_n10361
* NET  8228 = abc_29733_new_n10359
* NET  8229 = abc_29733_new_n10358
* NET  8230 = abc_29733_new_n10357
* NET  8231 = abc_29733_new_n10356
* NET  8232 = abc_29733_new_n10355
* NET  8233 = abc_29733_new_n10354
* NET  8234 = abc_29733_new_n10353
* NET  8235 = abc_29733_new_n10352
* NET  8236 = abc_29733_new_n10351
* NET  8237 = abc_29733_new_n10350
* NET  8238 = abc_29733_new_n10349
* NET  8239 = abc_29733_new_n10348
* NET  8240 = abc_29733_new_n10347
* NET  8241 = abc_29733_new_n10346
* NET  8242 = abc_29733_new_n10345
* NET  8243 = abc_29733_new_n10344
* NET  8244 = abc_29733_new_n10343
* NET  8245 = abc_29733_new_n10342
* NET  8246 = abc_29733_new_n10341
* NET  8247 = abc_29733_new_n10340
* NET  8248 = abc_29733_new_n10339
* NET  8249 = abc_29733_new_n10338
* NET  8250 = abc_29733_new_n10337
* NET  8251 = abc_29733_new_n10336
* NET  8252 = abc_29733_new_n10335
* NET  8253 = abc_29733_new_n10334
* NET  8254 = abc_29733_new_n10333
* NET  8255 = abc_29733_new_n10332
* NET  8256 = abc_29733_new_n10331
* NET  8257 = abc_29733_new_n10330
* NET  8258 = abc_29733_new_n10329
* NET  8259 = abc_29733_new_n10328
* NET  8260 = abc_29733_new_n10327
* NET  8261 = abc_29733_new_n10326
* NET  8262 = abc_29733_new_n10325
* NET  8263 = abc_29733_new_n10324
* NET  8264 = abc_29733_new_n10323
* NET  8265 = abc_29733_new_n10322
* NET  8266 = abc_29733_new_n10321
* NET  8267 = abc_29733_new_n10320
* NET  8268 = abc_29733_new_n10319
* NET  8269 = abc_29733_new_n10318
* NET  8270 = abc_29733_new_n10317
* NET  8271 = abc_29733_new_n10316
* NET  8272 = abc_29733_new_n10315
* NET  8273 = abc_29733_new_n10314
* NET  8274 = abc_29733_new_n10313
* NET  8275 = abc_29733_new_n10312
* NET  8276 = abc_29733_new_n10310
* NET  8277 = abc_29733_new_n10309
* NET  8278 = abc_29733_new_n10308
* NET  8279 = abc_29733_new_n10307
* NET  8280 = abc_29733_new_n10306
* NET  8281 = abc_29733_new_n10305
* NET  8282 = abc_29733_new_n10304
* NET  8283 = abc_29733_new_n10303
* NET  8284 = abc_29733_new_n10302
* NET  8285 = abc_29733_new_n10301
* NET  8286 = abc_29733_new_n10300
* NET  8287 = abc_29733_new_n10299
* NET  8288 = abc_29733_new_n10298
* NET  8289 = abc_29733_new_n10297
* NET  8290 = abc_29733_new_n10296
* NET  8291 = abc_29733_new_n10295
* NET  8292 = abc_29733_new_n10294
* NET  8293 = abc_29733_new_n10293
* NET  8294 = abc_29733_new_n10292
* NET  8295 = abc_29733_new_n10291
* NET  8296 = abc_29733_new_n10290
* NET  8297 = abc_29733_new_n10289
* NET  8298 = abc_29733_new_n10288
* NET  8299 = abc_29733_new_n10287
* NET  8300 = abc_29733_new_n10286
* NET  8301 = abc_29733_new_n10285
* NET  8302 = abc_29733_new_n10284
* NET  8303 = abc_29733_new_n10283
* NET  8304 = abc_29733_new_n10282
* NET  8305 = abc_29733_new_n10281
* NET  8306 = abc_29733_new_n10280
* NET  8307 = abc_29733_new_n10279
* NET  8308 = abc_29733_new_n10278
* NET  8309 = abc_29733_new_n10277
* NET  8310 = abc_29733_new_n10275
* NET  8311 = abc_29733_new_n10274
* NET  8312 = abc_29733_new_n10273
* NET  8313 = abc_29733_new_n10272
* NET  8314 = abc_29733_new_n10271
* NET  8315 = abc_29733_new_n10270
* NET  8316 = abc_29733_new_n10269
* NET  8317 = abc_29733_new_n10268
* NET  8318 = abc_29733_new_n10267
* NET  8319 = abc_29733_new_n10266
* NET  8320 = abc_29733_new_n10265
* NET  8321 = abc_29733_new_n10264
* NET  8322 = abc_29733_new_n10263
* NET  8323 = abc_29733_new_n10262
* NET  8324 = abc_29733_new_n10261
* NET  8325 = abc_29733_new_n10260
* NET  8326 = abc_29733_new_n10259
* NET  8327 = abc_29733_new_n10258
* NET  8328 = abc_29733_new_n10257
* NET  8329 = abc_29733_new_n10256
* NET  8330 = abc_29733_new_n10255
* NET  8331 = abc_29733_new_n10254
* NET  8332 = abc_29733_new_n10253
* NET  8333 = abc_29733_new_n10252
* NET  8334 = abc_29733_new_n10251
* NET  8335 = abc_29733_new_n10250
* NET  8336 = abc_29733_new_n10249
* NET  8337 = abc_29733_new_n10248
* NET  8338 = abc_29733_new_n10247
* NET  8339 = abc_29733_new_n10246
* NET  8340 = abc_29733_new_n10245
* NET  8341 = abc_29733_new_n10244
* NET  8342 = abc_29733_new_n10243
* NET  8343 = abc_29733_new_n10242
* NET  8344 = abc_29733_new_n10241
* NET  8345 = abc_29733_new_n10240
* NET  8346 = abc_29733_new_n10239
* NET  8347 = abc_29733_new_n10238
* NET  8348 = abc_29733_new_n10237
* NET  8349 = abc_29733_new_n10236
* NET  8350 = abc_29733_new_n10235
* NET  8351 = abc_29733_new_n10234
* NET  8352 = abc_29733_new_n10233
* NET  8353 = abc_29733_new_n10231
* NET  8354 = abc_29733_new_n10230
* NET  8355 = abc_29733_new_n10229
* NET  8356 = abc_29733_new_n10228
* NET  8357 = abc_29733_new_n10227
* NET  8358 = abc_29733_new_n10226
* NET  8359 = abc_29733_new_n10225
* NET  8360 = abc_29733_new_n10224
* NET  8361 = abc_29733_new_n10223
* NET  8362 = abc_29733_new_n10222
* NET  8363 = abc_29733_new_n10221
* NET  8364 = abc_29733_new_n10220
* NET  8365 = abc_29733_new_n10219
* NET  8366 = abc_29733_new_n10218
* NET  8367 = abc_29733_new_n10217
* NET  8368 = abc_29733_new_n10216
* NET  8369 = abc_29733_new_n10215
* NET  8370 = abc_29733_new_n10214
* NET  8371 = abc_29733_new_n10213
* NET  8372 = abc_29733_new_n10212
* NET  8373 = abc_29733_new_n10211
* NET  8374 = abc_29733_new_n10210
* NET  8375 = abc_29733_new_n10209
* NET  8376 = abc_29733_new_n10208
* NET  8377 = abc_29733_new_n10207
* NET  8378 = abc_29733_new_n10206
* NET  8379 = abc_29733_new_n10205
* NET  8380 = abc_29733_new_n10204
* NET  8381 = abc_29733_new_n10203
* NET  8382 = abc_29733_new_n10202
* NET  8383 = abc_29733_new_n10201
* NET  8384 = abc_29733_new_n10200
* NET  8385 = abc_29733_new_n10199
* NET  8386 = abc_29733_new_n10198
* NET  8387 = abc_29733_new_n10197
* NET  8388 = abc_29733_new_n10196
* NET  8389 = abc_29733_new_n10195
* NET  8390 = abc_29733_new_n10194
* NET  8391 = abc_29733_new_n10193
* NET  8392 = abc_29733_new_n10192
* NET  8393 = abc_29733_new_n10191
* NET  8394 = abc_29733_new_n10190
* NET  8395 = abc_29733_new_n10189
* NET  8396 = abc_29733_new_n10188
* NET  8397 = abc_29733_new_n10187
* NET  8398 = abc_29733_new_n10186
* NET  8399 = abc_29733_new_n10185
* NET  8400 = abc_29733_new_n10183
* NET  8401 = abc_29733_new_n10182
* NET  8402 = abc_29733_new_n10181
* NET  8403 = abc_29733_new_n10180
* NET  8404 = abc_29733_new_n10179
* NET  8405 = abc_29733_new_n10178
* NET  8406 = abc_29733_new_n10177
* NET  8407 = abc_29733_new_n10176
* NET  8408 = abc_29733_new_n10175
* NET  8409 = abc_29733_new_n10174
* NET  8410 = abc_29733_new_n10173
* NET  8411 = abc_29733_new_n10172
* NET  8412 = abc_29733_new_n10171
* NET  8413 = abc_29733_new_n10170
* NET  8414 = abc_29733_new_n10169
* NET  8415 = abc_29733_new_n10168
* NET  8416 = abc_29733_new_n10167
* NET  8417 = abc_29733_new_n10166
* NET  8418 = abc_29733_new_n10165
* NET  8419 = abc_29733_new_n10164
* NET  8420 = abc_29733_new_n10163
* NET  8421 = abc_29733_new_n10162
* NET  8422 = abc_29733_new_n10161
* NET  8423 = abc_29733_new_n10160
* NET  8424 = abc_29733_new_n10159
* NET  8425 = abc_29733_new_n10158
* NET  8426 = abc_29733_new_n10157
* NET  8427 = abc_29733_new_n10156
* NET  8428 = abc_29733_new_n10155
* NET  8429 = abc_29733_new_n10154
* NET  8430 = abc_29733_new_n10153
* NET  8431 = abc_29733_new_n10152
* NET  8432 = abc_29733_new_n10151
* NET  8433 = abc_29733_new_n10150
* NET  8434 = abc_29733_new_n10149
* NET  8435 = abc_29733_new_n10148
* NET  8436 = abc_29733_new_n10147
* NET  8437 = abc_29733_new_n10146
* NET  8438 = abc_29733_new_n10145
* NET  8439 = abc_29733_new_n10144
* NET  8440 = abc_29733_new_n10143
* NET  8441 = abc_29733_new_n10142
* NET  8442 = abc_29733_new_n10141
* NET  8443 = abc_29733_new_n10140
* NET  8444 = abc_29733_new_n10139
* NET  8445 = abc_29733_new_n10138
* NET  8446 = abc_29733_new_n10137
* NET  8447 = abc_29733_new_n10135
* NET  8448 = abc_29733_new_n10134
* NET  8449 = abc_29733_new_n10133
* NET  8450 = abc_29733_new_n10132
* NET  8451 = abc_29733_new_n10131
* NET  8452 = abc_29733_new_n10130
* NET  8453 = abc_29733_new_n10129
* NET  8454 = abc_29733_new_n10128
* NET  8455 = abc_29733_new_n10127
* NET  8456 = abc_29733_new_n10126
* NET  8457 = abc_29733_new_n10125
* NET  8458 = abc_29733_new_n10124
* NET  8459 = abc_29733_new_n10123
* NET  8460 = abc_29733_new_n10122
* NET  8461 = abc_29733_new_n10121
* NET  8462 = abc_29733_new_n10120
* NET  8463 = abc_29733_new_n10119
* NET  8464 = abc_29733_new_n10118
* NET  8465 = abc_29733_new_n10117
* NET  8466 = abc_29733_new_n10116
* NET  8467 = abc_29733_new_n10115
* NET  8468 = abc_29733_new_n10114
* NET  8469 = abc_29733_new_n10113
* NET  8470 = abc_29733_new_n10112
* NET  8471 = abc_29733_new_n10111
* NET  8472 = abc_29733_new_n10110
* NET  8473 = abc_29733_new_n10109
* NET  8474 = abc_29733_new_n10108
* NET  8475 = abc_29733_new_n10107
* NET  8476 = abc_29733_new_n10106
* NET  8477 = abc_29733_new_n10105
* NET  8478 = abc_29733_new_n10104
* NET  8479 = abc_29733_new_n10103
* NET  8480 = abc_29733_new_n10102
* NET  8481 = abc_29733_new_n10101
* NET  8482 = abc_29733_new_n10100
* NET  8483 = abc_29733_new_n10099
* NET  8484 = abc_29733_new_n10098
* NET  8485 = abc_29733_new_n10097
* NET  8486 = abc_29733_new_n10096
* NET  8487 = abc_29733_new_n10095
* NET  8488 = abc_29733_new_n10094
* NET  8489 = abc_29733_new_n10093
* NET  8490 = abc_29733_new_n10092
* NET  8491 = abc_29733_new_n10091
* NET  8492 = abc_29733_new_n10090
* NET  8493 = abc_29733_new_n10089
* NET  8494 = abc_29733_new_n10087
* NET  8495 = abc_29733_new_n10086
* NET  8496 = abc_29733_new_n10085
* NET  8497 = abc_29733_new_n10084
* NET  8498 = abc_29733_new_n10083
* NET  8499 = abc_29733_new_n10082
* NET  8500 = abc_29733_new_n10081
* NET  8501 = abc_29733_new_n10080
* NET  8502 = abc_29733_new_n10079
* NET  8503 = abc_29733_new_n10078
* NET  8504 = abc_29733_new_n10077
* NET  8505 = abc_29733_new_n10076
* NET  8506 = abc_29733_new_n10075
* NET  8507 = abc_29733_new_n10074
* NET  8508 = abc_29733_new_n10073
* NET  8509 = abc_29733_new_n10072
* NET  8510 = abc_29733_new_n10071
* NET  8511 = abc_29733_new_n10070
* NET  8512 = abc_29733_new_n10069
* NET  8513 = abc_29733_new_n10068
* NET  8514 = abc_29733_new_n10067
* NET  8515 = abc_29733_new_n10066
* NET  8516 = abc_29733_new_n10065
* NET  8517 = abc_29733_new_n10064
* NET  8518 = abc_29733_new_n10063
* NET  8519 = abc_29733_new_n10062
* NET  8520 = abc_29733_new_n10061
* NET  8521 = abc_29733_new_n10060
* NET  8522 = abc_29733_new_n10059
* NET  8523 = abc_29733_new_n10058
* NET  8524 = abc_29733_new_n10057
* NET  8525 = abc_29733_new_n10056
* NET  8526 = abc_29733_new_n10055
* NET  8527 = abc_29733_new_n10054
* NET  8528 = abc_29733_new_n10053
* NET  8529 = abc_29733_new_n10052
* NET  8530 = abc_29733_new_n10051
* NET  8531 = abc_29733_new_n10050
* NET  8532 = abc_29733_new_n10049
* NET  8533 = abc_29733_new_n10048
* NET  8534 = abc_29733_new_n10047
* NET  8535 = abc_29733_new_n10046
* NET  8536 = abc_29733_new_n10045
* NET  8537 = abc_29733_new_n10044
* NET  8538 = abc_29733_new_n10043
* NET  8539 = abc_29733_new_n10042
* NET  8540 = abc_29733_new_n10041
* NET  8541 = abc_29733_new_n10039
* NET  8542 = abc_29733_new_n10038
* NET  8543 = abc_29733_new_n10037
* NET  8544 = abc_29733_new_n10036
* NET  8545 = abc_29733_new_n10035
* NET  8546 = abc_29733_new_n10034
* NET  8547 = abc_29733_new_n10033
* NET  8548 = abc_29733_new_n10032
* NET  8549 = abc_29733_new_n10031
* NET  8550 = abc_29733_new_n10030
* NET  8551 = abc_29733_new_n10029
* NET  8552 = abc_29733_new_n10028
* NET  8553 = abc_29733_new_n10027
* NET  8554 = abc_29733_new_n10026
* NET  8555 = abc_29733_new_n10025
* NET  8556 = abc_29733_new_n10024
* NET  8557 = abc_29733_new_n10023
* NET  8558 = abc_29733_new_n10022
* NET  8559 = abc_29733_new_n10021
* NET  8560 = abc_29733_new_n10020
* NET  8561 = abc_29733_new_n10019
* NET  8562 = abc_29733_new_n10018
* NET  8563 = abc_29733_new_n10017
* NET  8564 = abc_29733_new_n10016
* NET  8565 = abc_29733_new_n10015
* NET  8566 = abc_29733_new_n10014
* NET  8567 = abc_29733_new_n10013
* NET  8568 = abc_29733_new_n10012
* NET  8569 = abc_29733_new_n10011
* NET  8570 = abc_29733_new_n10010
* NET  8571 = abc_29733_new_n10009
* NET  8572 = abc_29733_new_n10008
* NET  8573 = abc_29733_new_n10007
* NET  8574 = abc_29733_new_n10006
* NET  8575 = abc_29733_new_n10005
* NET  8576 = abc_29733_new_n10004
* NET  8577 = abc_29733_new_n10003
* NET  8578 = abc_29733_new_n10002
* NET  8579 = abc_29733_new_n10001
* NET  8580 = abc_29733_new_n10000
* NET  8581 = abc_29733_auto_rtlil_cc_2560_MuxGate_29732
* NET  8582 = abc_29733_auto_rtlil_cc_2560_MuxGate_29728
* NET  8583 = abc_29733_auto_rtlil_cc_2560_MuxGate_29726
* NET  8584 = abc_29733_auto_rtlil_cc_2560_MuxGate_29724
* NET  8585 = abc_29733_auto_rtlil_cc_2560_MuxGate_29722
* NET  8586 = abc_29733_auto_rtlil_cc_2560_MuxGate_29720
* NET  8587 = abc_29733_auto_rtlil_cc_2560_MuxGate_29718
* NET  8588 = abc_29733_auto_rtlil_cc_2560_MuxGate_29716
* NET  8589 = abc_29733_auto_rtlil_cc_2560_MuxGate_29714
* NET  8590 = abc_29733_auto_rtlil_cc_2560_MuxGate_29712
* NET  8591 = abc_29733_auto_rtlil_cc_2560_MuxGate_29710
* NET  8592 = abc_29733_auto_rtlil_cc_2560_MuxGate_29708
* NET  8593 = abc_29733_auto_rtlil_cc_2560_MuxGate_29706
* NET  8594 = abc_29733_auto_rtlil_cc_2560_MuxGate_29704
* NET  8595 = abc_29733_auto_rtlil_cc_2560_MuxGate_29702
* NET  8596 = abc_29733_auto_rtlil_cc_2560_MuxGate_29700
* NET  8597 = abc_29733_auto_rtlil_cc_2560_MuxGate_29698
* NET  8598 = abc_29733_auto_rtlil_cc_2560_MuxGate_29696
* NET  8599 = abc_29733_auto_rtlil_cc_2560_MuxGate_29694
* NET  8600 = abc_29733_auto_rtlil_cc_2560_MuxGate_29692
* NET  8601 = abc_29733_auto_rtlil_cc_2560_MuxGate_29690
* NET  8602 = abc_29733_auto_rtlil_cc_2560_MuxGate_29688
* NET  8603 = abc_29733_auto_rtlil_cc_2560_MuxGate_29686
* NET  8604 = abc_29733_auto_rtlil_cc_2560_MuxGate_29684
* NET  8605 = abc_29733_auto_rtlil_cc_2560_MuxGate_29682
* NET  8606 = abc_29733_auto_rtlil_cc_2560_MuxGate_29680
* NET  8607 = abc_29733_auto_rtlil_cc_2560_MuxGate_29678
* NET  8608 = abc_29733_auto_rtlil_cc_2560_MuxGate_29676
* NET  8609 = abc_29733_auto_rtlil_cc_2560_MuxGate_29674
* NET  8610 = abc_29733_auto_rtlil_cc_2560_MuxGate_29672
* NET  8611 = abc_29733_auto_rtlil_cc_2560_MuxGate_29670
* NET  8612 = abc_29733_auto_rtlil_cc_2560_MuxGate_29668
* NET  8613 = abc_29733_auto_rtlil_cc_2560_MuxGate_29666
* NET  8614 = abc_29733_auto_rtlil_cc_2560_MuxGate_29664
* NET  8615 = abc_29733_auto_rtlil_cc_2560_MuxGate_29662
* NET  8616 = abc_29733_auto_rtlil_cc_2560_MuxGate_29660
* NET  8617 = abc_29733_auto_rtlil_cc_2560_MuxGate_29658
* NET  8618 = abc_29733_auto_rtlil_cc_2560_MuxGate_29656
* NET  8619 = abc_29733_auto_rtlil_cc_2560_MuxGate_29654
* NET  8620 = abc_29733_auto_rtlil_cc_2560_MuxGate_29652
* NET  8621 = abc_29733_auto_rtlil_cc_2560_MuxGate_29650
* NET  8622 = abc_29733_auto_rtlil_cc_2560_MuxGate_29648
* NET  8623 = abc_29733_auto_rtlil_cc_2560_MuxGate_29646
* NET  8624 = abc_29733_auto_rtlil_cc_2560_MuxGate_29644
* NET  8625 = abc_29733_auto_rtlil_cc_2560_MuxGate_29642
* NET  8626 = abc_29733_auto_rtlil_cc_2560_MuxGate_29640
* NET  8627 = abc_29733_auto_rtlil_cc_2560_MuxGate_29638
* NET  8628 = abc_29733_auto_rtlil_cc_2560_MuxGate_29636
* NET  8629 = abc_29733_auto_rtlil_cc_2560_MuxGate_29634
* NET  8630 = abc_29733_auto_rtlil_cc_2560_MuxGate_29632
* NET  8631 = abc_29733_auto_rtlil_cc_2560_MuxGate_29630
* NET  8632 = abc_29733_auto_rtlil_cc_2560_MuxGate_29628
* NET  8633 = abc_29733_auto_rtlil_cc_2560_MuxGate_29626
* NET  8634 = abc_29733_auto_rtlil_cc_2560_MuxGate_29624
* NET  8635 = abc_29733_auto_rtlil_cc_2560_MuxGate_29622
* NET  8636 = abc_29733_auto_rtlil_cc_2560_MuxGate_29620
* NET  8637 = abc_29733_auto_rtlil_cc_2560_MuxGate_29618
* NET  8638 = abc_29733_auto_rtlil_cc_2560_MuxGate_29616
* NET  8639 = abc_29733_auto_rtlil_cc_2560_MuxGate_29614
* NET  8640 = abc_29733_auto_rtlil_cc_2560_MuxGate_29612
* NET  8641 = abc_29733_auto_rtlil_cc_2560_MuxGate_29610
* NET  8642 = abc_29733_auto_rtlil_cc_2560_MuxGate_29608
* NET  8643 = abc_29733_auto_rtlil_cc_2560_MuxGate_29606
* NET  8644 = abc_29733_auto_rtlil_cc_2560_MuxGate_29604
* NET  8645 = abc_29733_auto_rtlil_cc_2560_MuxGate_29602
* NET  8646 = abc_29733_auto_rtlil_cc_2560_MuxGate_29600
* NET  8647 = abc_29733_auto_rtlil_cc_2560_MuxGate_29598
* NET  8648 = abc_29733_auto_rtlil_cc_2560_MuxGate_29596
* NET  8649 = abc_29733_auto_rtlil_cc_2560_MuxGate_29594
* NET  8650 = abc_29733_auto_rtlil_cc_2560_MuxGate_29592
* NET  8651 = abc_29733_auto_rtlil_cc_2560_MuxGate_29590
* NET  8652 = abc_29733_auto_rtlil_cc_2560_MuxGate_29588
* NET  8653 = abc_29733_auto_rtlil_cc_2560_MuxGate_29586
* NET  8654 = abc_29733_auto_rtlil_cc_2560_MuxGate_29584
* NET  8655 = abc_29733_auto_rtlil_cc_2560_MuxGate_29582
* NET  8656 = abc_29733_auto_rtlil_cc_2560_MuxGate_29580
* NET  8657 = abc_29733_auto_rtlil_cc_2560_MuxGate_29578
* NET  8658 = abc_29733_auto_rtlil_cc_2560_MuxGate_29576
* NET  8659 = abc_29733_auto_rtlil_cc_2560_MuxGate_29574
* NET  8660 = abc_29733_auto_rtlil_cc_2560_MuxGate_29572
* NET  8661 = abc_29733_auto_rtlil_cc_2560_MuxGate_29570
* NET  8662 = abc_29733_auto_rtlil_cc_2560_MuxGate_29568
* NET  8663 = abc_29733_auto_rtlil_cc_2560_MuxGate_29566
* NET  8664 = abc_29733_auto_rtlil_cc_2560_MuxGate_29564
* NET  8665 = abc_29733_auto_rtlil_cc_2560_MuxGate_29562
* NET  8666 = abc_29733_auto_rtlil_cc_2560_MuxGate_29560
* NET  8667 = abc_29733_auto_rtlil_cc_2560_MuxGate_29558
* NET  8668 = abc_29733_auto_rtlil_cc_2560_MuxGate_29556
* NET  8669 = abc_29733_auto_rtlil_cc_2560_MuxGate_29554
* NET  8670 = abc_29733_auto_rtlil_cc_2560_MuxGate_29552
* NET  8671 = abc_29733_auto_rtlil_cc_2560_MuxGate_29550
* NET  8672 = abc_29733_auto_rtlil_cc_2560_MuxGate_29548
* NET  8673 = abc_29733_auto_rtlil_cc_2560_MuxGate_29546
* NET  8674 = abc_29733_auto_rtlil_cc_2560_MuxGate_29544
* NET  8675 = abc_29733_auto_rtlil_cc_2560_MuxGate_29542
* NET  8676 = abc_29733_auto_rtlil_cc_2560_MuxGate_29540
* NET  8677 = abc_29733_auto_rtlil_cc_2560_MuxGate_29538
* NET  8678 = abc_29733_auto_rtlil_cc_2560_MuxGate_29536
* NET  8679 = abc_29733_auto_rtlil_cc_2560_MuxGate_29534
* NET  8680 = abc_29733_auto_rtlil_cc_2560_MuxGate_29532
* NET  8681 = abc_29733_auto_rtlil_cc_2560_MuxGate_29530
* NET  8682 = abc_29733_auto_rtlil_cc_2560_MuxGate_29528
* NET  8683 = abc_29733_auto_rtlil_cc_2560_MuxGate_29526
* NET  8684 = abc_29733_auto_rtlil_cc_2560_MuxGate_29524
* NET  8685 = abc_29733_auto_rtlil_cc_2560_MuxGate_29522
* NET  8686 = abc_29733_auto_rtlil_cc_2560_MuxGate_29520
* NET  8687 = abc_29733_auto_rtlil_cc_2560_MuxGate_29518
* NET  8688 = abc_29733_auto_rtlil_cc_2560_MuxGate_29516
* NET  8689 = abc_29733_auto_rtlil_cc_2560_MuxGate_29514
* NET  8690 = abc_29733_auto_rtlil_cc_2560_MuxGate_29512
* NET  8691 = abc_29733_auto_rtlil_cc_2560_MuxGate_29510
* NET  8692 = abc_29733_auto_rtlil_cc_2560_MuxGate_29508
* NET  8693 = abc_29733_auto_rtlil_cc_2560_MuxGate_29506
* NET  8694 = abc_29733_auto_rtlil_cc_2560_MuxGate_29504
* NET  8695 = abc_29733_auto_rtlil_cc_2560_MuxGate_29502
* NET  8696 = abc_29733_auto_rtlil_cc_2560_MuxGate_29500
* NET  8697 = abc_29733_auto_rtlil_cc_2560_MuxGate_29498
* NET  8698 = abc_29733_auto_rtlil_cc_2560_MuxGate_29496
* NET  8699 = abc_29733_auto_rtlil_cc_2560_MuxGate_29494
* NET  8700 = abc_29733_auto_rtlil_cc_2560_MuxGate_29492
* NET  8701 = abc_29733_auto_rtlil_cc_2560_MuxGate_29490
* NET  8702 = abc_29733_auto_rtlil_cc_2560_MuxGate_29488
* NET  8703 = abc_29733_auto_rtlil_cc_2560_MuxGate_29486
* NET  8704 = abc_29733_auto_rtlil_cc_2560_MuxGate_29484
* NET  8705 = abc_29733_auto_rtlil_cc_2560_MuxGate_29482
* NET  8706 = abc_29733_auto_rtlil_cc_2560_MuxGate_29480
* NET  8707 = abc_29733_auto_rtlil_cc_2560_MuxGate_29478
* NET  8708 = abc_29733_auto_rtlil_cc_2560_MuxGate_29476
* NET  8709 = abc_29733_auto_rtlil_cc_2560_MuxGate_29474
* NET  8710 = abc_29733_auto_rtlil_cc_2560_MuxGate_29472
* NET  8711 = abc_29733_auto_rtlil_cc_2560_MuxGate_29470
* NET  8712 = abc_29733_auto_rtlil_cc_2560_MuxGate_29468
* NET  8713 = abc_29733_auto_rtlil_cc_2560_MuxGate_29466
* NET  8714 = abc_29733_auto_rtlil_cc_2560_MuxGate_29464
* NET  8715 = abc_29733_auto_rtlil_cc_2560_MuxGate_29462
* NET  8716 = abc_29733_auto_rtlil_cc_2560_MuxGate_29460
* NET  8717 = abc_29733_auto_rtlil_cc_2560_MuxGate_29458
* NET  8718 = abc_29733_auto_rtlil_cc_2560_MuxGate_29456
* NET  8719 = abc_29733_auto_rtlil_cc_2560_MuxGate_29454
* NET  8720 = abc_29733_auto_rtlil_cc_2560_MuxGate_29452
* NET  8721 = abc_29733_auto_rtlil_cc_2560_MuxGate_29450
* NET  8722 = abc_29733_auto_rtlil_cc_2560_MuxGate_29448
* NET  8723 = abc_29733_auto_rtlil_cc_2560_MuxGate_29446
* NET  8724 = abc_29733_auto_rtlil_cc_2560_MuxGate_29444
* NET  8725 = abc_29733_auto_rtlil_cc_2560_MuxGate_29442
* NET  8726 = abc_29733_auto_rtlil_cc_2560_MuxGate_29440
* NET  8727 = abc_29733_auto_rtlil_cc_2560_MuxGate_29438
* NET  8728 = abc_29733_auto_rtlil_cc_2560_MuxGate_29436
* NET  8729 = abc_29733_auto_rtlil_cc_2560_MuxGate_29434
* NET  8730 = abc_29733_auto_rtlil_cc_2560_MuxGate_29432
* NET  8731 = abc_29733_auto_rtlil_cc_2560_MuxGate_29430
* NET  8732 = abc_29733_auto_rtlil_cc_2560_MuxGate_29428
* NET  8733 = abc_29733_auto_rtlil_cc_2560_MuxGate_29426
* NET  8734 = abc_29733_auto_rtlil_cc_2560_MuxGate_29424
* NET  8735 = abc_29733_auto_rtlil_cc_2560_MuxGate_29422
* NET  8736 = abc_29733_auto_rtlil_cc_2560_MuxGate_29420
* NET  8737 = abc_29733_auto_rtlil_cc_2560_MuxGate_29418
* NET  8738 = abc_29733_auto_rtlil_cc_2560_MuxGate_29416
* NET  8739 = abc_29733_auto_rtlil_cc_2560_MuxGate_29414
* NET  8740 = abc_29733_auto_rtlil_cc_2560_MuxGate_29412
* NET  8741 = abc_29733_auto_rtlil_cc_2560_MuxGate_29410
* NET  8742 = abc_29733_auto_rtlil_cc_2560_MuxGate_29408
* NET  8743 = abc_29733_auto_rtlil_cc_2560_MuxGate_29406
* NET  8744 = abc_29733_auto_rtlil_cc_2560_MuxGate_29404
* NET  8745 = abc_29733_auto_rtlil_cc_2560_MuxGate_29402
* NET  8746 = abc_29733_auto_rtlil_cc_2560_MuxGate_29400
* NET  8747 = abc_29733_auto_rtlil_cc_2560_MuxGate_29398
* NET  8748 = abc_29733_auto_rtlil_cc_2560_MuxGate_29396
* NET  8749 = abc_29733_auto_rtlil_cc_2560_MuxGate_29394
* NET  8750 = abc_29733_auto_rtlil_cc_2560_MuxGate_29392
* NET  8751 = abc_29733_auto_rtlil_cc_2560_MuxGate_29390
* NET  8752 = abc_29733_auto_rtlil_cc_2560_MuxGate_29388
* NET  8753 = abc_29733_auto_rtlil_cc_2560_MuxGate_29386
* NET  8754 = abc_29733_auto_rtlil_cc_2560_MuxGate_29384
* NET  8755 = abc_29733_auto_rtlil_cc_2560_MuxGate_29382
* NET  8756 = abc_29733_auto_rtlil_cc_2560_MuxGate_29380
* NET  8757 = abc_29733_auto_rtlil_cc_2560_MuxGate_29378
* NET  8758 = abc_29733_auto_rtlil_cc_2560_MuxGate_29376
* NET  8759 = abc_29733_auto_rtlil_cc_2560_MuxGate_29374
* NET  8760 = abc_29733_auto_rtlil_cc_2560_MuxGate_29372
* NET  8761 = abc_29733_auto_rtlil_cc_2560_MuxGate_29370
* NET  8762 = abc_29733_auto_rtlil_cc_2560_MuxGate_29368
* NET  8763 = abc_29733_auto_rtlil_cc_2560_MuxGate_29366
* NET  8764 = abc_29733_auto_rtlil_cc_2560_MuxGate_29364
* NET  8765 = abc_29733_auto_rtlil_cc_2560_MuxGate_29362
* NET  8766 = abc_29733_auto_rtlil_cc_2560_MuxGate_29360
* NET  8767 = abc_29733_auto_rtlil_cc_2560_MuxGate_29358
* NET  8768 = abc_29733_auto_rtlil_cc_2560_MuxGate_29356
* NET  8769 = abc_29733_auto_rtlil_cc_2560_MuxGate_29354
* NET  8770 = abc_29733_auto_rtlil_cc_2560_MuxGate_29352
* NET  8771 = abc_29733_auto_rtlil_cc_2560_MuxGate_29350
* NET  8772 = abc_29733_auto_rtlil_cc_2560_MuxGate_29348
* NET  8773 = abc_29733_auto_rtlil_cc_2560_MuxGate_29346
* NET  8774 = abc_29733_auto_rtlil_cc_2560_MuxGate_29344
* NET  8775 = abc_29733_auto_rtlil_cc_2560_MuxGate_29342
* NET  8776 = abc_29733_auto_rtlil_cc_2560_MuxGate_29340
* NET  8777 = abc_29733_auto_rtlil_cc_2560_MuxGate_29338
* NET  8778 = abc_29733_auto_rtlil_cc_2560_MuxGate_29336
* NET  8779 = abc_29733_auto_rtlil_cc_2560_MuxGate_29334
* NET  8780 = abc_29733_auto_rtlil_cc_2560_MuxGate_29332
* NET  8781 = abc_29733_auto_rtlil_cc_2560_MuxGate_29330
* NET  8782 = abc_29733_auto_rtlil_cc_2560_MuxGate_29328
* NET  8783 = abc_29733_auto_rtlil_cc_2560_MuxGate_29326
* NET  8784 = abc_29733_auto_rtlil_cc_2560_MuxGate_29324
* NET  8785 = abc_29733_auto_rtlil_cc_2560_MuxGate_29322
* NET  8786 = abc_29733_auto_rtlil_cc_2560_MuxGate_29320
* NET  8787 = abc_29733_auto_rtlil_cc_2560_MuxGate_29318
* NET  8788 = abc_29733_auto_rtlil_cc_2560_MuxGate_29316
* NET  8789 = abc_29733_auto_rtlil_cc_2560_MuxGate_29314
* NET  8790 = abc_29733_auto_rtlil_cc_2560_MuxGate_29312
* NET  8791 = abc_29733_auto_rtlil_cc_2560_MuxGate_29310
* NET  8792 = abc_29733_auto_rtlil_cc_2560_MuxGate_29308
* NET  8793 = abc_29733_auto_rtlil_cc_2560_MuxGate_29306
* NET  8794 = abc_29733_auto_rtlil_cc_2560_MuxGate_29304
* NET  8795 = abc_29733_auto_rtlil_cc_2560_MuxGate_29302
* NET  8796 = abc_29733_auto_rtlil_cc_2560_MuxGate_29300
* NET  8797 = abc_29733_auto_rtlil_cc_2560_MuxGate_29298
* NET  8798 = abc_29733_auto_rtlil_cc_2560_MuxGate_29296
* NET  8799 = abc_29733_auto_rtlil_cc_2560_MuxGate_29294
* NET  8800 = abc_29733_auto_rtlil_cc_2560_MuxGate_29292
* NET  8801 = abc_29733_auto_rtlil_cc_2560_MuxGate_29290
* NET  8802 = abc_29733_auto_rtlil_cc_2560_MuxGate_29288
* NET  8803 = abc_29733_auto_rtlil_cc_2560_MuxGate_29286
* NET  8804 = abc_29733_auto_rtlil_cc_2560_MuxGate_29284
* NET  8805 = abc_29733_auto_rtlil_cc_2560_MuxGate_29282
* NET  8806 = abc_29733_auto_rtlil_cc_2560_MuxGate_29280
* NET  8807 = abc_29733_auto_rtlil_cc_2560_MuxGate_29278
* NET  8808 = abc_29733_auto_rtlil_cc_2560_MuxGate_29276
* NET  8809 = abc_29733_auto_rtlil_cc_2560_MuxGate_29274
* NET  8810 = abc_29733_auto_rtlil_cc_2560_MuxGate_29272
* NET  8811 = abc_29733_auto_rtlil_cc_2560_MuxGate_29270
* NET  8812 = abc_29733_auto_rtlil_cc_2560_MuxGate_29268
* NET  8813 = abc_29733_auto_rtlil_cc_2560_MuxGate_29266
* NET  8814 = abc_29733_auto_rtlil_cc_2560_MuxGate_29264
* NET  8815 = abc_29733_auto_rtlil_cc_2560_MuxGate_29262
* NET  8816 = abc_29733_auto_rtlil_cc_2560_MuxGate_29260
* NET  8817 = abc_29733_auto_rtlil_cc_2560_MuxGate_29258
* NET  8818 = abc_29733_auto_rtlil_cc_2560_MuxGate_29256
* NET  8819 = abc_29733_auto_rtlil_cc_2560_MuxGate_29254
* NET  8820 = abc_29733_auto_rtlil_cc_2560_MuxGate_29252
* NET  8821 = abc_29733_auto_rtlil_cc_2560_MuxGate_29250
* NET  8822 = abc_29733_auto_rtlil_cc_2560_MuxGate_29248
* NET  8823 = abc_29733_auto_rtlil_cc_2560_MuxGate_29246
* NET  8824 = abc_29733_auto_rtlil_cc_2560_MuxGate_29244
* NET  8825 = abc_29733_auto_rtlil_cc_2560_MuxGate_29242
* NET  8826 = abc_29733_auto_rtlil_cc_2560_MuxGate_29240
* NET  8827 = abc_29733_auto_rtlil_cc_2560_MuxGate_29238
* NET  8828 = abc_29733_auto_rtlil_cc_2560_MuxGate_29236
* NET  8829 = abc_29733_auto_rtlil_cc_2560_MuxGate_29234
* NET  8830 = abc_29733_auto_rtlil_cc_2560_MuxGate_29232
* NET  8831 = abc_29733_auto_rtlil_cc_2560_MuxGate_29230
* NET  8832 = abc_29733_auto_rtlil_cc_2560_MuxGate_29228
* NET  8833 = abc_29733_auto_rtlil_cc_2560_MuxGate_29226
* NET  8834 = abc_29733_auto_rtlil_cc_2560_MuxGate_29224
* NET  8835 = abc_29733_auto_rtlil_cc_2560_MuxGate_29222
* NET  8836 = abc_29733_auto_rtlil_cc_2560_MuxGate_29220
* NET  8837 = abc_29733_auto_rtlil_cc_2560_MuxGate_29218
* NET  8838 = abc_29733_auto_rtlil_cc_2560_MuxGate_29216
* NET  8839 = abc_29733_auto_rtlil_cc_2560_MuxGate_29214
* NET  8840 = abc_29733_auto_rtlil_cc_2560_MuxGate_29212
* NET  8841 = abc_29733_auto_rtlil_cc_2560_MuxGate_29210
* NET  8842 = abc_29733_auto_rtlil_cc_2560_MuxGate_29208
* NET  8843 = abc_29733_auto_rtlil_cc_2560_MuxGate_29206
* NET  8844 = abc_29733_auto_rtlil_cc_2560_MuxGate_29204
* NET  8845 = abc_29733_auto_rtlil_cc_2560_MuxGate_29202
* NET  8846 = abc_29733_auto_rtlil_cc_2560_MuxGate_29200
* NET  8847 = abc_29733_auto_rtlil_cc_2560_MuxGate_29198
* NET  8848 = abc_29733_auto_rtlil_cc_2560_MuxGate_29196
* NET  8849 = abc_29733_auto_rtlil_cc_2560_MuxGate_29194
* NET  8850 = abc_29733_auto_rtlil_cc_2560_MuxGate_29192
* NET  8851 = abc_29733_auto_rtlil_cc_2560_MuxGate_29190
* NET  8852 = abc_29733_auto_rtlil_cc_2560_MuxGate_29188
* NET  8853 = abc_29733_auto_rtlil_cc_2560_MuxGate_29186
* NET  8854 = abc_29733_auto_rtlil_cc_2560_MuxGate_29184
* NET  8855 = abc_29733_auto_rtlil_cc_2560_MuxGate_29182
* NET  8856 = abc_29733_auto_rtlil_cc_2560_MuxGate_29180
* NET  8857 = abc_29733_auto_rtlil_cc_2560_MuxGate_29178
* NET  8858 = abc_29733_auto_rtlil_cc_2560_MuxGate_29176
* NET  8859 = abc_29733_auto_rtlil_cc_2560_MuxGate_29174
* NET  8860 = abc_29733_auto_rtlil_cc_2560_MuxGate_29172
* NET  8861 = abc_29733_auto_rtlil_cc_2560_MuxGate_29170
* NET  8862 = abc_29733_auto_rtlil_cc_2560_MuxGate_29168
* NET  8863 = abc_29733_auto_rtlil_cc_2560_MuxGate_29166
* NET  8864 = abc_29733_auto_rtlil_cc_2560_MuxGate_29164
* NET  8865 = abc_29733_auto_rtlil_cc_2560_MuxGate_29162
* NET  8866 = abc_29733_auto_rtlil_cc_2560_MuxGate_29160
* NET  8867 = abc_29733_auto_rtlil_cc_2560_MuxGate_29158
* NET  8868 = abc_29733_auto_rtlil_cc_2560_MuxGate_29156
* NET  8869 = abc_29733_auto_rtlil_cc_2560_MuxGate_29154
* NET  8870 = abc_29733_auto_rtlil_cc_2560_MuxGate_29152
* NET  8871 = abc_29733_auto_rtlil_cc_2560_MuxGate_29150
* NET  8872 = abc_29733_auto_rtlil_cc_2560_MuxGate_29148
* NET  8873 = abc_29733_auto_rtlil_cc_2560_MuxGate_29146
* NET  8874 = abc_29733_auto_rtlil_cc_2560_MuxGate_29144
* NET  8875 = abc_29733_auto_rtlil_cc_2560_MuxGate_29142
* NET  8876 = abc_29733_auto_rtlil_cc_2560_MuxGate_29140
* NET  8877 = abc_29733_auto_rtlil_cc_2560_MuxGate_29138
* NET  8878 = abc_29733_auto_rtlil_cc_2560_MuxGate_29136
* NET  8879 = abc_29733_auto_rtlil_cc_2560_MuxGate_29134
* NET  8880 = abc_29733_auto_rtlil_cc_2560_MuxGate_29132
* NET  8881 = abc_29733_auto_rtlil_cc_2560_MuxGate_29130
* NET  8882 = abc_29733_auto_rtlil_cc_2560_MuxGate_29128
* NET  8883 = abc_29733_auto_rtlil_cc_2560_MuxGate_29126
* NET  8884 = abc_29733_auto_rtlil_cc_2560_MuxGate_29124
* NET  8885 = abc_29733_auto_rtlil_cc_2560_MuxGate_29122
* NET  8886 = abc_29733_auto_rtlil_cc_2560_MuxGate_29120
* NET  8887 = abc_29733_auto_rtlil_cc_2560_MuxGate_29118
* NET  8888 = abc_29733_auto_rtlil_cc_2560_MuxGate_29116
* NET  8889 = abc_29733_auto_rtlil_cc_2560_MuxGate_29114
* NET  8890 = abc_29733_auto_rtlil_cc_2560_MuxGate_29112
* NET  8891 = abc_29733_auto_rtlil_cc_2560_MuxGate_29110
* NET  8892 = abc_29733_auto_rtlil_cc_2560_MuxGate_29108
* NET  8893 = abc_29733_auto_rtlil_cc_2560_MuxGate_29106
* NET  8894 = abc_29733_auto_rtlil_cc_2560_MuxGate_29104
* NET  8895 = abc_29733_auto_rtlil_cc_2560_MuxGate_29102
* NET  8896 = abc_29733_auto_rtlil_cc_2560_MuxGate_29100
* NET  8897 = abc_29733_auto_rtlil_cc_2560_MuxGate_29098
* NET  8898 = abc_29733_auto_rtlil_cc_2560_MuxGate_29096
* NET  8899 = abc_29733_auto_rtlil_cc_2560_MuxGate_29094
* NET  8900 = abc_29733_auto_rtlil_cc_2560_MuxGate_29092
* NET  8901 = abc_29733_auto_rtlil_cc_2560_MuxGate_29090
* NET  8902 = abc_29733_auto_rtlil_cc_2560_MuxGate_29088
* NET  8903 = abc_29733_auto_rtlil_cc_2560_MuxGate_29086
* NET  8904 = abc_29733_auto_rtlil_cc_2560_MuxGate_29084
* NET  8905 = abc_29733_auto_rtlil_cc_2560_MuxGate_29082
* NET  8906 = abc_29733_auto_rtlil_cc_2560_MuxGate_29080
* NET  8907 = abc_29733_auto_rtlil_cc_2560_MuxGate_29078
* NET  8908 = abc_29733_auto_rtlil_cc_2560_MuxGate_29076
* NET  8909 = abc_29733_auto_rtlil_cc_2560_MuxGate_29074
* NET  8910 = abc_29733_auto_rtlil_cc_2560_MuxGate_29072
* NET  8911 = abc_29733_auto_rtlil_cc_2560_MuxGate_29070
* NET  8912 = abc_29733_auto_rtlil_cc_2560_MuxGate_29068
* NET  8913 = abc_29733_auto_rtlil_cc_2560_MuxGate_29066
* NET  8914 = abc_29733_auto_rtlil_cc_2560_MuxGate_29064
* NET  8915 = abc_29733_auto_rtlil_cc_2560_MuxGate_29062
* NET  8916 = abc_29733_auto_rtlil_cc_2560_MuxGate_29060
* NET  8917 = abc_29733_auto_rtlil_cc_2560_MuxGate_29058
* NET  8918 = abc_29733_auto_rtlil_cc_2560_MuxGate_29056
* NET  8919 = abc_29733_auto_rtlil_cc_2560_MuxGate_29054
* NET  8920 = abc_29733_auto_rtlil_cc_2560_MuxGate_29052
* NET  8921 = abc_29733_auto_rtlil_cc_2560_MuxGate_29050
* NET  8922 = abc_29733_auto_rtlil_cc_2560_MuxGate_29048
* NET  8923 = abc_29733_auto_rtlil_cc_2560_MuxGate_29046
* NET  8924 = abc_29733_auto_rtlil_cc_2560_MuxGate_29044
* NET  8925 = abc_29733_auto_rtlil_cc_2560_MuxGate_29042
* NET  8926 = abc_29733_auto_rtlil_cc_2560_MuxGate_29040
* NET  8927 = abc_29733_auto_rtlil_cc_2560_MuxGate_29038
* NET  8928 = abc_29733_auto_rtlil_cc_2560_MuxGate_29036
* NET  8929 = abc_29733_auto_rtlil_cc_2560_MuxGate_29034
* NET  8930 = abc_29733_auto_rtlil_cc_2560_MuxGate_29032
* NET  8931 = abc_29733_auto_rtlil_cc_2560_MuxGate_29030
* NET  8932 = abc_29733_auto_rtlil_cc_2560_MuxGate_29028
* NET  8933 = abc_29733_auto_rtlil_cc_2560_MuxGate_29026
* NET  8934 = abc_29733_auto_rtlil_cc_2560_MuxGate_29024
* NET  8935 = abc_29733_auto_rtlil_cc_2560_MuxGate_29022
* NET  8936 = abc_29733_auto_rtlil_cc_2560_MuxGate_29020
* NET  8937 = abc_29733_auto_rtlil_cc_2560_MuxGate_29018
* NET  8938 = abc_29733_auto_rtlil_cc_2560_MuxGate_29016
* NET  8939 = abc_29733_auto_rtlil_cc_2560_MuxGate_29014
* NET  8940 = abc_29733_auto_rtlil_cc_2560_MuxGate_29012
* NET  8941 = abc_29733_auto_rtlil_cc_2560_MuxGate_29010
* NET  8942 = abc_29733_auto_rtlil_cc_2560_MuxGate_29008
* NET  8943 = abc_29733_auto_rtlil_cc_2560_MuxGate_29006
* NET  8944 = abc_29733_auto_rtlil_cc_2560_MuxGate_29004
* NET  8945 = abc_29733_auto_rtlil_cc_2560_MuxGate_29002
* NET  8946 = abc_29733_auto_rtlil_cc_2560_MuxGate_29000
* NET  8947 = abc_29733_auto_rtlil_cc_2560_MuxGate_28998
* NET  8948 = abc_29733_auto_rtlil_cc_2560_MuxGate_28996
* NET  8949 = abc_29733_auto_rtlil_cc_2560_MuxGate_28994
* NET  8950 = abc_29733_auto_rtlil_cc_2560_MuxGate_28992
* NET  8951 = abc_29733_auto_rtlil_cc_2560_MuxGate_28990
* NET  8952 = abc_29733_auto_rtlil_cc_2560_MuxGate_28988
* NET  8953 = abc_29733_auto_rtlil_cc_2560_MuxGate_28986
* NET  8954 = abc_29733_auto_rtlil_cc_2560_MuxGate_28984
* NET  8955 = abc_29733_auto_rtlil_cc_2560_MuxGate_28982
* NET  8956 = abc_29733_auto_rtlil_cc_2560_MuxGate_28980
* NET  8957 = abc_29733_auto_rtlil_cc_2560_MuxGate_28978
* NET  8958 = abc_29733_auto_rtlil_cc_2560_MuxGate_28976
* NET  8959 = abc_29733_auto_rtlil_cc_2560_MuxGate_28974
* NET  8960 = abc_29733_auto_rtlil_cc_2560_MuxGate_28972
* NET  8961 = abc_29733_auto_rtlil_cc_2560_MuxGate_28970
* NET  8962 = abc_29733_auto_rtlil_cc_2560_MuxGate_28968
* NET  8963 = abc_29733_auto_rtlil_cc_2560_MuxGate_28966
* NET  8964 = abc_29733_auto_rtlil_cc_2560_MuxGate_28964
* NET  8965 = abc_29733_auto_rtlil_cc_2560_MuxGate_28962
* NET  8966 = abc_29733_auto_rtlil_cc_2560_MuxGate_28960
* NET  8967 = abc_29733_auto_rtlil_cc_2560_MuxGate_28958
* NET  8968 = abc_29733_auto_rtlil_cc_2560_MuxGate_28956
* NET  8969 = abc_29733_auto_rtlil_cc_2560_MuxGate_28954
* NET  8970 = abc_29733_auto_rtlil_cc_2560_MuxGate_28952
* NET  8971 = abc_29733_auto_rtlil_cc_2560_MuxGate_28950
* NET  8972 = abc_29733_auto_rtlil_cc_2560_MuxGate_28948
* NET  8973 = abc_29733_auto_rtlil_cc_2560_MuxGate_28946
* NET  8974 = abc_29733_auto_rtlil_cc_2560_MuxGate_28944
* NET  8975 = abc_29733_auto_rtlil_cc_2560_MuxGate_28942
* NET  8976 = abc_29733_auto_rtlil_cc_2560_MuxGate_28940
* NET  8977 = abc_29733_auto_rtlil_cc_2560_MuxGate_28938
* NET  8978 = abc_29733_auto_rtlil_cc_2560_MuxGate_28936
* NET  8979 = abc_29733_auto_rtlil_cc_2560_MuxGate_28934
* NET  8980 = abc_29733_auto_rtlil_cc_2560_MuxGate_28932
* NET  8981 = abc_29733_auto_rtlil_cc_2560_MuxGate_28930
* NET  8982 = abc_29733_auto_rtlil_cc_2560_MuxGate_28928
* NET  8983 = abc_29733_auto_rtlil_cc_2560_MuxGate_28926
* NET  8984 = abc_29733_auto_rtlil_cc_2560_MuxGate_28924
* NET  8985 = abc_29733_auto_rtlil_cc_2560_MuxGate_28922
* NET  8986 = abc_29733_auto_rtlil_cc_2560_MuxGate_28920
* NET  8987 = abc_29733_auto_rtlil_cc_2560_MuxGate_28918
* NET  8988 = abc_29733_auto_rtlil_cc_2560_MuxGate_28916
* NET  8989 = abc_29733_auto_rtlil_cc_2560_MuxGate_28914
* NET  8990 = abc_29733_auto_rtlil_cc_2560_MuxGate_28912
* NET  8991 = abc_29733_auto_rtlil_cc_2560_MuxGate_28910
* NET  8992 = abc_29733_auto_rtlil_cc_2560_MuxGate_28908
* NET  8993 = abc_29733_auto_rtlil_cc_2560_MuxGate_28906
* NET  8994 = abc_29733_auto_rtlil_cc_2560_MuxGate_28904
* NET  8995 = abc_29733_auto_rtlil_cc_2560_MuxGate_28902
* NET  8996 = abc_29733_auto_rtlil_cc_2560_MuxGate_28900
* NET  8997 = abc_29733_auto_rtlil_cc_2560_MuxGate_28898
* NET  8998 = abc_29733_auto_rtlil_cc_2560_MuxGate_28896
* NET  8999 = abc_29733_auto_rtlil_cc_2560_MuxGate_28894
* NET  9000 = abc_29733_auto_rtlil_cc_2560_MuxGate_28892
* NET  9001 = abc_29733_auto_rtlil_cc_2560_MuxGate_28890
* NET  9002 = abc_29733_auto_rtlil_cc_2560_MuxGate_28888
* NET  9003 = abc_29733_auto_rtlil_cc_2560_MuxGate_28886
* NET  9004 = abc_29733_auto_rtlil_cc_2560_MuxGate_28884
* NET  9005 = abc_29733_auto_rtlil_cc_2560_MuxGate_28882
* NET  9006 = abc_29733_auto_rtlil_cc_2560_MuxGate_28880
* NET  9007 = abc_29733_auto_rtlil_cc_2560_MuxGate_28878
* NET  9008 = abc_29733_auto_rtlil_cc_2560_MuxGate_28876
* NET  9009 = abc_29733_auto_rtlil_cc_2560_MuxGate_28874
* NET  9010 = abc_29733_auto_rtlil_cc_2560_MuxGate_28872
* NET  9011 = abc_29733_auto_rtlil_cc_2560_MuxGate_28870
* NET  9012 = abc_29733_auto_rtlil_cc_2560_MuxGate_28868
* NET  9013 = abc_29733_auto_rtlil_cc_2560_MuxGate_28866
* NET  9014 = abc_29733_auto_rtlil_cc_2560_MuxGate_28864
* NET  9015 = abc_29733_auto_rtlil_cc_2560_MuxGate_28862
* NET  9016 = abc_29733_auto_rtlil_cc_2560_MuxGate_28860
* NET  9017 = abc_29733_auto_rtlil_cc_2560_MuxGate_28858
* NET  9018 = abc_29733_auto_rtlil_cc_2560_MuxGate_28856
* NET  9019 = abc_29733_auto_rtlil_cc_2560_MuxGate_28854
* NET  9020 = abc_29733_auto_rtlil_cc_2560_MuxGate_28852
* NET  9021 = abc_29733_auto_rtlil_cc_2560_MuxGate_28850
* NET  9022 = abc_29733_auto_rtlil_cc_2560_MuxGate_28848
* NET  9023 = abc_29733_auto_rtlil_cc_2560_MuxGate_28846
* NET  9024 = abc_29733_auto_rtlil_cc_2560_MuxGate_28844
* NET  9025 = abc_29733_auto_rtlil_cc_2560_MuxGate_28842
* NET  9026 = abc_29733_auto_rtlil_cc_2560_MuxGate_28840
* NET  9027 = abc_29733_auto_rtlil_cc_2560_MuxGate_28838
* NET  9028 = abc_29733_auto_rtlil_cc_2560_MuxGate_28836
* NET  9029 = abc_29733_auto_rtlil_cc_2560_MuxGate_28834
* NET  9030 = abc_29733_auto_rtlil_cc_2560_MuxGate_28832
* NET  9031 = abc_29733_auto_rtlil_cc_2560_MuxGate_28830
* NET  9032 = abc_29733_auto_rtlil_cc_2560_MuxGate_28828
* NET  9033 = abc_29733_auto_rtlil_cc_2560_MuxGate_28826
* NET  9034 = abc_29733_auto_rtlil_cc_2560_MuxGate_28824
* NET  9035 = abc_29733_auto_rtlil_cc_2560_MuxGate_28822
* NET  9036 = abc_29733_auto_rtlil_cc_2560_MuxGate_28820
* NET  9037 = abc_29733_auto_rtlil_cc_2560_MuxGate_28818
* NET  9038 = abc_29733_auto_rtlil_cc_2560_MuxGate_28816
* NET  9039 = abc_29733_auto_rtlil_cc_2560_MuxGate_28814
* NET  9040 = abc_29733_auto_rtlil_cc_2560_MuxGate_28812
* NET  9041 = abc_29733_auto_rtlil_cc_2560_MuxGate_28810
* NET  9042 = abc_29733_auto_rtlil_cc_2560_MuxGate_28808
* NET  9043 = abc_29733_auto_rtlil_cc_2560_MuxGate_28806
* NET  9044 = abc_29733_auto_rtlil_cc_2560_MuxGate_28804
* NET  9045 = abc_29733_auto_rtlil_cc_2560_MuxGate_28802
* NET  9046 = abc_29733_auto_rtlil_cc_2560_MuxGate_28800
* NET  9047 = abc_29733_auto_rtlil_cc_2560_MuxGate_28798
* NET  9048 = abc_29733_auto_rtlil_cc_2560_MuxGate_28796
* NET  9049 = abc_29733_auto_rtlil_cc_2560_MuxGate_28794
* NET  9050 = abc_29733_auto_rtlil_cc_2560_MuxGate_28792
* NET  9051 = abc_29733_auto_rtlil_cc_2560_MuxGate_28790
* NET  9052 = abc_29733_auto_rtlil_cc_2560_MuxGate_28788
* NET  9053 = abc_29733_auto_rtlil_cc_2560_MuxGate_28786
* NET  9054 = abc_29733_auto_rtlil_cc_2560_MuxGate_28784
* NET  9055 = abc_29733_auto_rtlil_cc_2560_MuxGate_28782
* NET  9056 = abc_29733_auto_rtlil_cc_2560_MuxGate_28780
* NET  9057 = abc_29733_auto_rtlil_cc_2560_MuxGate_28778
* NET  9058 = abc_29733_auto_rtlil_cc_2560_MuxGate_28776
* NET  9059 = abc_29733_auto_rtlil_cc_2560_MuxGate_28774
* NET  9060 = abc_29733_auto_rtlil_cc_2560_MuxGate_28772
* NET  9061 = abc_29733_auto_rtlil_cc_2560_MuxGate_28770
* NET  9062 = abc_29733_auto_rtlil_cc_2560_MuxGate_28768
* NET  9063 = abc_29733_auto_rtlil_cc_2560_MuxGate_28766
* NET  9064 = abc_29733_auto_rtlil_cc_2560_MuxGate_28764
* NET  9065 = abc_29733_auto_rtlil_cc_2560_MuxGate_28762
* NET  9066 = abc_29733_auto_rtlil_cc_2560_MuxGate_28760
* NET  9067 = abc_29733_auto_rtlil_cc_2560_MuxGate_28758
* NET  9068 = abc_29733_auto_rtlil_cc_2560_MuxGate_28756
* NET  9069 = abc_29733_auto_rtlil_cc_2560_MuxGate_28754
* NET  9070 = abc_29733_auto_rtlil_cc_2560_MuxGate_28752
* NET  9071 = abc_29733_auto_rtlil_cc_2560_MuxGate_28750
* NET  9072 = abc_29733_auto_rtlil_cc_2560_MuxGate_28748
* NET  9073 = abc_29733_auto_rtlil_cc_2560_MuxGate_28746
* NET  9074 = abc_29733_auto_rtlil_cc_2560_MuxGate_28744
* NET  9075 = abc_29733_auto_rtlil_cc_2560_MuxGate_28742
* NET  9076 = abc_29733_auto_rtlil_cc_2560_MuxGate_28740
* NET  9077 = abc_29733_auto_rtlil_cc_2560_MuxGate_28738
* NET  9078 = abc_29733_auto_rtlil_cc_2560_MuxGate_28736
* NET  9079 = abc_29733_auto_rtlil_cc_2560_MuxGate_28734
* NET  9080 = abc_29733_auto_rtlil_cc_2560_MuxGate_28732
* NET  9081 = abc_29733_auto_rtlil_cc_2560_MuxGate_28730
* NET  9082 = abc_29733_auto_rtlil_cc_2560_MuxGate_28728
* NET  9083 = abc_29733_auto_rtlil_cc_2560_MuxGate_28726
* NET  9084 = abc_29733_auto_rtlil_cc_2560_MuxGate_28724
* NET  9085 = abc_29733_auto_rtlil_cc_2560_MuxGate_28722
* NET  9086 = abc_29733_auto_rtlil_cc_2560_MuxGate_28720
* NET  9087 = abc_29733_auto_rtlil_cc_2560_MuxGate_28718
* NET  9088 = abc_29733_auto_rtlil_cc_2560_MuxGate_28716
* NET  9089 = abc_29733_auto_rtlil_cc_2560_MuxGate_28714
* NET  9090 = abc_29733_auto_rtlil_cc_2560_MuxGate_28712
* NET  9091 = abc_29733_auto_rtlil_cc_2560_MuxGate_28710
* NET  9092 = abc_29733_auto_rtlil_cc_2560_MuxGate_28708
* NET  9093 = abc_29733_auto_rtlil_cc_2560_MuxGate_28706
* NET  9094 = abc_29733_auto_rtlil_cc_2560_MuxGate_28704
* NET  9095 = abc_29733_auto_rtlil_cc_2560_MuxGate_28702
* NET  9096 = abc_29733_auto_rtlil_cc_2560_MuxGate_28700
* NET  9097 = abc_29733_auto_rtlil_cc_2560_MuxGate_28698
* NET  9098 = abc_29733_auto_rtlil_cc_2560_MuxGate_28696
* NET  9099 = abc_29733_auto_rtlil_cc_2560_MuxGate_28694
* NET  9100 = abc_29733_auto_rtlil_cc_2560_MuxGate_28692
* NET  9101 = abc_29733_auto_rtlil_cc_2560_MuxGate_28690
* NET  9102 = abc_29733_auto_rtlil_cc_2560_MuxGate_28688
* NET  9103 = abc_29733_auto_rtlil_cc_2560_MuxGate_28686
* NET  9104 = abc_29733_auto_rtlil_cc_2560_MuxGate_28684
* NET  9105 = abc_29733_auto_rtlil_cc_2560_MuxGate_28682
* NET  9106 = abc_29733_auto_rtlil_cc_2560_MuxGate_28680
* NET  9107 = abc_29733_auto_rtlil_cc_2560_MuxGate_28678
* NET  9108 = abc_29733_auto_rtlil_cc_2560_MuxGate_28676
* NET  9109 = abc_29733_auto_rtlil_cc_2560_MuxGate_28674
* NET  9110 = abc_29733_auto_rtlil_cc_2560_MuxGate_28672
* NET  9111 = abc_29733_auto_rtlil_cc_2560_MuxGate_28670
* NET  9112 = abc_29733_auto_rtlil_cc_2560_MuxGate_28668
* NET  9113 = abc_29733_auto_rtlil_cc_2560_MuxGate_28666
* NET  9114 = abc_29733_auto_rtlil_cc_2560_MuxGate_28664
* NET  9115 = abc_29733_auto_rtlil_cc_2560_MuxGate_28662
* NET  9116 = abc_29733_auto_rtlil_cc_2560_MuxGate_28660
* NET  9117 = abc_29733_auto_rtlil_cc_2560_MuxGate_28658
* NET  9118 = abc_29733_auto_rtlil_cc_2560_MuxGate_28656
* NET  9119 = abc_29733_auto_rtlil_cc_2560_MuxGate_28654
* NET  9120 = abc_29733_auto_rtlil_cc_2560_MuxGate_28652
* NET  9121 = abc_29733_auto_rtlil_cc_2560_MuxGate_28650
* NET  9122 = abc_29733_auto_rtlil_cc_2560_MuxGate_28648
* NET  9123 = abc_29733_auto_rtlil_cc_2560_MuxGate_28646
* NET  9124 = abc_29733_auto_rtlil_cc_2560_MuxGate_28644
* NET  9125 = abc_29733_auto_rtlil_cc_2560_MuxGate_28642
* NET  9126 = abc_29733_auto_rtlil_cc_2560_MuxGate_28640
* NET  9127 = abc_29733_auto_rtlil_cc_2560_MuxGate_28638
* NET  9128 = abc_29733_auto_rtlil_cc_2560_MuxGate_28636
* NET  9129 = abc_29733_auto_rtlil_cc_2560_MuxGate_28634
* NET  9130 = abc_29733_auto_rtlil_cc_2560_MuxGate_28632
* NET  9131 = abc_29733_auto_rtlil_cc_2560_MuxGate_28630
* NET  9132 = abc_29733_auto_rtlil_cc_2560_MuxGate_28628
* NET  9133 = abc_29733_auto_rtlil_cc_2560_MuxGate_28626
* NET  9134 = abc_29733_auto_rtlil_cc_2560_MuxGate_28624
* NET  9135 = abc_29733_auto_rtlil_cc_2560_MuxGate_28622
* NET  9136 = abc_29733_auto_rtlil_cc_2560_MuxGate_28620
* NET  9137 = abc_29733_auto_rtlil_cc_2560_MuxGate_28618
* NET  9138 = abc_29733_auto_rtlil_cc_2560_MuxGate_28616
* NET  9139 = abc_29733_auto_rtlil_cc_2560_MuxGate_28614
* NET  9140 = abc_29733_auto_rtlil_cc_2560_MuxGate_28612
* NET  9141 = abc_29733_auto_rtlil_cc_2560_MuxGate_28610
* NET  9142 = abc_29733_auto_rtlil_cc_2560_MuxGate_28608
* NET  9143 = abc_29733_auto_rtlil_cc_2560_MuxGate_28606
* NET  9144 = abc_29733_auto_rtlil_cc_2560_MuxGate_28604
* NET  9145 = abc_29733_auto_rtlil_cc_2560_MuxGate_28602
* NET  9146 = abc_29733_auto_rtlil_cc_2560_MuxGate_28600
* NET  9147 = abc_29733_auto_rtlil_cc_2560_MuxGate_28598
* NET  9148 = abc_29733_auto_rtlil_cc_2560_MuxGate_28596
* NET  9149 = abc_29733_auto_rtlil_cc_2560_MuxGate_28594
* NET  9150 = abc_29733_auto_rtlil_cc_2560_MuxGate_28592
* NET  9151 = abc_29733_auto_rtlil_cc_2560_MuxGate_28590
* NET  9152 = abc_29733_auto_rtlil_cc_2560_MuxGate_28588
* NET  9153 = abc_29733_auto_rtlil_cc_2560_MuxGate_28586
* NET  9154 = abc_29733_auto_rtlil_cc_2560_MuxGate_28584
* NET  9155 = abc_29733_auto_rtlil_cc_2560_MuxGate_28582
* NET  9156 = abc_29733_auto_rtlil_cc_2560_MuxGate_28580
* NET  9157 = abc_29733_auto_rtlil_cc_2560_MuxGate_28578
* NET  9158 = abc_29733_auto_rtlil_cc_2560_MuxGate_28576
* NET  9159 = abc_29733_auto_rtlil_cc_2560_MuxGate_28574
* NET  9160 = abc_29733_auto_rtlil_cc_2560_MuxGate_28572
* NET  9161 = abc_29733_auto_rtlil_cc_2560_MuxGate_28568
* NET  9162 = abc_29733_auto_rtlil_cc_2560_MuxGate_28564
* NET  9163 = abc_29733_auto_rtlil_cc_2560_MuxGate_28560
* NET  9164 = abc_29733_auto_rtlil_cc_2560_MuxGate_28556
* NET  9165 = abc_29733_auto_rtlil_cc_2560_MuxGate_28552
* NET  9166 = abc_29733_auto_rtlil_cc_2560_MuxGate_28548
* NET  9167 = abc_29733_auto_rtlil_cc_2560_MuxGate_28544
* NET  9168 = abc_29733_auto_rtlil_cc_2560_MuxGate_28540
* NET  9169 = abc_29733_auto_rtlil_cc_2560_MuxGate_28536
* NET  9170 = abc_29733_auto_rtlil_cc_2560_MuxGate_28532
* NET  9171 = abc_29733_auto_rtlil_cc_2560_MuxGate_28528
* NET  9172 = abc_29733_auto_rtlil_cc_2560_MuxGate_28524
* NET  9173 = abc_29733_auto_rtlil_cc_2560_MuxGate_28520
* NET  9174 = abc_29733_auto_rtlil_cc_2560_MuxGate_28516
* NET  9175 = abc_29733_auto_rtlil_cc_2560_MuxGate_28512
* NET  9176 = abc_29733_auto_rtlil_cc_2560_MuxGate_28508
* NET  9177 = abc_29733_auto_rtlil_cc_2560_MuxGate_28504
* NET  9178 = abc_29733_auto_rtlil_cc_2560_MuxGate_28500
* NET  9179 = abc_29733_auto_rtlil_cc_2560_MuxGate_28496
* NET  9180 = abc_29733_auto_rtlil_cc_2560_MuxGate_28492
* NET  9181 = abc_29733_auto_rtlil_cc_2560_MuxGate_28488
* NET  9182 = abc_29733_auto_rtlil_cc_2560_MuxGate_28484
* NET  9183 = abc_29733_auto_rtlil_cc_2560_MuxGate_28480
* NET  9184 = abc_29733_auto_rtlil_cc_2560_MuxGate_28476
* NET  9185 = abc_29733_auto_rtlil_cc_2560_MuxGate_28472
* NET  9186 = abc_29733_auto_rtlil_cc_2560_MuxGate_28468
* NET  9187 = abc_29733_auto_rtlil_cc_2560_MuxGate_28464
* NET  9188 = abc_29733_auto_rtlil_cc_2560_MuxGate_28460
* NET  9189 = abc_29733_auto_rtlil_cc_2560_MuxGate_28456
* NET  9190 = abc_29733_auto_rtlil_cc_2560_MuxGate_28452
* NET  9191 = abc_29733_auto_rtlil_cc_2560_MuxGate_28448
* NET  9192 = abc_29733_auto_rtlil_cc_2560_MuxGate_28444
* NET  9193 = abc_29733_auto_rtlil_cc_2560_MuxGate_28440
* NET  9194 = abc_29733_auto_rtlil_cc_2560_MuxGate_28436
* NET  9195 = abc_29733_auto_rtlil_cc_2560_MuxGate_28432
* NET  9196 = abc_29733_auto_rtlil_cc_2560_MuxGate_28428
* NET  9197 = abc_29733_auto_rtlil_cc_2560_MuxGate_28426
* NET  9198 = abc_29733_auto_rtlil_cc_2560_MuxGate_28424
* NET  9199 = abc_29733_auto_rtlil_cc_2560_MuxGate_28422
* NET  9200 = abc_29733_auto_rtlil_cc_2560_MuxGate_28420
* NET  9201 = abc_29733_auto_rtlil_cc_2560_MuxGate_28418
* NET  9202 = abc_29733_auto_rtlil_cc_2560_MuxGate_28416
* NET  9203 = abc_29733_auto_rtlil_cc_2560_MuxGate_28414
* NET  9204 = abc_29733_auto_rtlil_cc_2560_MuxGate_28412
* NET  9205 = abc_29733_auto_rtlil_cc_2560_MuxGate_28410
* NET  9206 = abc_29733_auto_rtlil_cc_2560_MuxGate_28408
* NET  9207 = abc_29733_auto_rtlil_cc_2560_MuxGate_28406
* NET  9208 = abc_29733_auto_rtlil_cc_2560_MuxGate_28404
* NET  9209 = abc_29733_auto_rtlil_cc_2560_MuxGate_28402
* NET  9210 = abc_29733_auto_rtlil_cc_2560_MuxGate_28400
* NET  9211 = abc_29733_auto_rtlil_cc_2560_MuxGate_28398
* NET  9212 = abc_29733_auto_rtlil_cc_2560_MuxGate_28396
* NET  9213 = abc_29733_auto_rtlil_cc_2560_MuxGate_28394
* NET  9214 = abc_29733_auto_rtlil_cc_2560_MuxGate_28392
* NET  9215 = abc_29733_auto_rtlil_cc_2560_MuxGate_28390
* NET  9216 = abc_29733_auto_rtlil_cc_2560_MuxGate_28388
* NET  9217 = abc_29733_auto_rtlil_cc_2560_MuxGate_28386
* NET  9218 = abc_29733_auto_rtlil_cc_2560_MuxGate_28384
* NET  9219 = abc_29733_auto_rtlil_cc_2560_MuxGate_28382
* NET  9220 = abc_29733_auto_rtlil_cc_2560_MuxGate_28380
* NET  9221 = abc_29733_auto_rtlil_cc_2560_MuxGate_28378
* NET  9222 = abc_29733_auto_rtlil_cc_2560_MuxGate_28376
* NET  9223 = abc_29733_auto_rtlil_cc_2560_MuxGate_28374
* NET  9224 = abc_29733_auto_rtlil_cc_2560_MuxGate_28372
* NET  9225 = abc_29733_auto_rtlil_cc_2560_MuxGate_28370
* NET  9226 = abc_29733_auto_rtlil_cc_2560_MuxGate_28368
* NET  9227 = abc_29733_auto_rtlil_cc_2560_MuxGate_28366
* NET  9228 = abc_29733_auto_rtlil_cc_2560_MuxGate_28364
* NET  9229 = abc_29733_auto_rtlil_cc_2560_MuxGate_28362
* NET  9230 = abc_29733_auto_rtlil_cc_2560_MuxGate_28360
* NET  9231 = abc_29733_auto_rtlil_cc_2560_MuxGate_28358
* NET  9232 = abc_29733_auto_rtlil_cc_2560_MuxGate_28356
* NET  9233 = abc_29733_auto_rtlil_cc_2560_MuxGate_28352
* NET  9234 = abc_29733_auto_rtlil_cc_2560_MuxGate_28348
* NET  9235 = abc_29733_auto_rtlil_cc_2560_MuxGate_28344
* NET  9236 = abc_29733_auto_rtlil_cc_2560_MuxGate_28342
* NET  9237 = abc_29733_auto_rtlil_cc_2560_MuxGate_28340
* NET  9238 = abc_29733_auto_rtlil_cc_2560_MuxGate_28338
* NET  9239 = abc_29733_auto_rtlil_cc_2560_MuxGate_28334
* NET  9240 = abc_29733_auto_rtlil_cc_2560_MuxGate_28332
* NET  9241 = abc_29733_auto_rtlil_cc_2560_MuxGate_28330
* NET  9242 = abc_29733_auto_rtlil_cc_2560_MuxGate_28328
* NET  9243 = abc_29733_auto_rtlil_cc_2560_MuxGate_28326
* NET  9244 = abc_29733_auto_rtlil_cc_2560_MuxGate_28324
* NET  9245 = abc_29733_auto_rtlil_cc_2560_MuxGate_28322
* NET  9246 = abc_29733_auto_rtlil_cc_2560_MuxGate_28320
* NET  9247 = abc_29733_auto_rtlil_cc_2560_MuxGate_28318
* NET  9248 = abc_29733_auto_rtlil_cc_2560_MuxGate_28316
* NET  9249 = abc_29733_auto_rtlil_cc_2560_MuxGate_28314
* NET  9250 = abc_29733_auto_rtlil_cc_2560_MuxGate_28312
* NET  9251 = abc_29733_auto_rtlil_cc_2560_MuxGate_28310
* NET  9252 = abc_29733_auto_rtlil_cc_2560_MuxGate_28308
* NET  9253 = abc_29733_auto_rtlil_cc_2560_MuxGate_28306
* NET  9254 = abc_29733_auto_rtlil_cc_2560_MuxGate_28304
* NET  9255 = abc_29733_auto_rtlil_cc_2560_MuxGate_28302
* NET  9256 = abc_29733_auto_rtlil_cc_2560_MuxGate_28300
* NET  9257 = abc_29733_auto_rtlil_cc_2560_MuxGate_28298
* NET  9258 = abc_29733_auto_rtlil_cc_2560_MuxGate_28296
* NET  9259 = abc_29733_auto_rtlil_cc_2560_MuxGate_28294
* NET  9260 = abc_29733_auto_rtlil_cc_2560_MuxGate_28292
* NET  9261 = abc_29733_auto_rtlil_cc_2560_MuxGate_28290
* NET  9262 = abc_29733_auto_rtlil_cc_2560_MuxGate_28288
* NET  9263 = abc_29733_auto_rtlil_cc_2560_MuxGate_28286
* NET  9264 = abc_29733_auto_rtlil_cc_2560_MuxGate_28284
* NET  9265 = abc_29733_auto_rtlil_cc_2560_MuxGate_28282
* NET  9266 = abc_29733_auto_rtlil_cc_2560_MuxGate_28280
* NET  9267 = abc_29733_auto_rtlil_cc_2560_MuxGate_28278
* NET  9268 = abc_29733_auto_rtlil_cc_2560_MuxGate_28276
* NET  9269 = abc_29733_auto_rtlil_cc_2560_MuxGate_28274
* NET  9270 = abc_29733_auto_rtlil_cc_2560_MuxGate_28272
* NET  9271 = abc_29733_auto_rtlil_cc_2560_MuxGate_28270
* NET  9272 = abc_29733_auto_rtlil_cc_2560_MuxGate_28268
* NET  9273 = abc_29733_auto_rtlil_cc_2560_MuxGate_28266
* NET  9274 = abc_29733_auto_rtlil_cc_2560_MuxGate_28264
* NET  9275 = abc_29733_auto_rtlil_cc_2560_MuxGate_28262
* NET  9276 = abc_29733_auto_rtlil_cc_2560_MuxGate_28258
* NET  9277 = abc_29733_auto_rtlil_cc_2560_MuxGate_28254
* NET  9278 = abc_29733_auto_rtlil_cc_2560_MuxGate_28250
* NET  9279 = abc_29733_auto_rtlil_cc_2560_MuxGate_28246
* NET  9280 = abc_29733_auto_rtlil_cc_2560_MuxGate_28242
* NET  9281 = abc_29733_auto_rtlil_cc_2560_MuxGate_28238
* NET  9282 = abc_29733_auto_rtlil_cc_2560_MuxGate_28234
* NET  9283 = abc_29733_auto_rtlil_cc_2560_MuxGate_28230
* NET  9284 = abc_29733_auto_rtlil_cc_2560_MuxGate_28226
* NET  9285 = abc_29733_auto_rtlil_cc_2560_MuxGate_28222
* NET  9286 = abc_29733_auto_rtlil_cc_2560_MuxGate_28220
* NET  9287 = abc_29733_auto_rtlil_cc_2560_MuxGate_28218
* NET  9288 = abc_29733_auto_rtlil_cc_2560_MuxGate_28216
* NET  9289 = abc_29733_auto_rtlil_cc_2560_MuxGate_28212
* NET  9290 = abc_29733_auto_rtlil_cc_2560_MuxGate_28208
* NET  9291 = abc_29733_auto_rtlil_cc_2560_MuxGate_28204
* NET  9292 = abc_29733_auto_rtlil_cc_2560_MuxGate_28200
* NET  9293 = abc_29733_auto_rtlil_cc_2560_MuxGate_28196
* NET  9294 = abc_29733_auto_rtlil_cc_2560_MuxGate_28192
* NET  9295 = abc_29733_auto_rtlil_cc_2560_MuxGate_28190
* NET  9296 = abc_29733_auto_rtlil_cc_2560_MuxGate_28188
* NET  9297 = abc_29733_auto_rtlil_cc_2560_MuxGate_28186
* NET  9298 = abc_29733_auto_rtlil_cc_2560_MuxGate_28184
* NET  9299 = abc_29733_auto_rtlil_cc_2560_MuxGate_28182
* NET  9300 = abc_29733_auto_rtlil_cc_2560_MuxGate_28180
* NET  9301 = abc_29733_auto_rtlil_cc_2560_MuxGate_28178
* NET  9302 = abc_29733_auto_rtlil_cc_2560_MuxGate_28176
* NET  9303 = abc_29733_auto_rtlil_cc_2560_MuxGate_28172
* NET  9304 = abc_29733_auto_rtlil_cc_2560_MuxGate_28168
* NET  9305 = abc_29733_auto_rtlil_cc_2560_MuxGate_28164
* NET  9306 = abc_29733_auto_rtlil_cc_2560_MuxGate_28160
* NET  9307 = abc_29733_auto_rtlil_cc_2560_MuxGate_28156
* NET  9308 = abc_29733_auto_rtlil_cc_2560_MuxGate_28152
* NET  9309 = abc_29733_auto_rtlil_cc_2560_MuxGate_28150
* NET  9310 = abc_29733_auto_rtlil_cc_2560_MuxGate_28148
* NET  9311 = abc_29733_auto_rtlil_cc_2560_MuxGate_28146
* NET  9312 = abc_29733_auto_rtlil_cc_2560_MuxGate_28144
* NET  9313 = abc_29733_auto_rtlil_cc_2560_MuxGate_28142
* NET  9314 = abc_29733_auto_rtlil_cc_2560_MuxGate_28140
* NET  9315 = abc_29733_auto_rtlil_cc_2560_MuxGate_28138
* NET  9316 = abc_29733_auto_rtlil_cc_2560_MuxGate_28136
* NET  9317 = abc_29733_auto_rtlil_cc_2560_MuxGate_28134
* NET  9318 = abc_29733_auto_rtlil_cc_2560_MuxGate_28132
* NET  9319 = abc_29733_auto_rtlil_cc_2560_MuxGate_28130
* NET  9320 = abc_29733_auto_rtlil_cc_2560_MuxGate_28128
* NET  9321 = abc_29733_auto_rtlil_cc_2560_MuxGate_28126
* NET  9322 = abc_29733_auto_rtlil_cc_2560_MuxGate_28124
* NET  9323 = abc_29733_auto_rtlil_cc_2560_MuxGate_28122
* NET  9324 = abc_29733_auto_rtlil_cc_2560_MuxGate_28120
* NET  9325 = abc_29733_auto_rtlil_cc_2560_MuxGate_28118
* NET  9326 = abc_29733_auto_rtlil_cc_2560_MuxGate_28116
* NET  9327 = abc_29733_auto_rtlil_cc_2560_MuxGate_28114
* NET  9328 = abc_29733_auto_rtlil_cc_2560_MuxGate_28112
* NET  9329 = abc_29733_auto_rtlil_cc_2560_MuxGate_28110
* NET  9330 = abc_29733_auto_rtlil_cc_2560_MuxGate_28108
* NET  9331 = abc_29733_auto_rtlil_cc_2560_MuxGate_28106
* NET  9332 = abc_29733_auto_rtlil_cc_2560_MuxGate_28104
* NET  9333 = abc_29733_auto_rtlil_cc_2560_MuxGate_28102
* NET  9334 = abc_29733_auto_rtlil_cc_2560_MuxGate_28100
* NET  9335 = abc_29733_auto_rtlil_cc_2560_MuxGate_28098
* NET  9336 = abc_29733_auto_rtlil_cc_2560_MuxGate_28096
* NET  9337 = abc_29733_auto_rtlil_cc_2560_MuxGate_28094
* NET  9338 = abc_29733_auto_rtlil_cc_2560_MuxGate_28092
* NET  9339 = abc_29733_auto_rtlil_cc_2560_MuxGate_28090
* NET  9340 = abc_29733_auto_rtlil_cc_2560_MuxGate_28088
* NET  9341 = abc_29733_auto_rtlil_cc_2560_MuxGate_28086
* NET  9342 = abc_29733_auto_rtlil_cc_2560_MuxGate_28084
* NET  9343 = abc_29733_auto_rtlil_cc_2560_MuxGate_28082
* NET  9344 = abc_29733_auto_rtlil_cc_2560_MuxGate_28078
* NET  9345 = abc_29733_auto_rtlil_cc_2560_MuxGate_28074
* NET  9346 = abc_29733_auto_rtlil_cc_2560_MuxGate_28072
* NET  9347 = abc_29733_auto_rtlil_cc_2560_MuxGate_28070
* NET  9348 = abc_29733_auto_rtlil_cc_2560_MuxGate_28068
* NET  9349 = abc_29733_auto_rtlil_cc_2560_MuxGate_28066
* NET  9350 = abc_29733_auto_rtlil_cc_2560_MuxGate_28064
* NET  9351 = abc_29733_auto_rtlil_cc_2560_MuxGate_28062
* NET  9352 = abc_29733_auto_rtlil_cc_2560_MuxGate_28060
* NET  9353 = abc_29733_auto_rtlil_cc_2560_MuxGate_28058
* NET  9354 = abc_29733_auto_rtlil_cc_2560_MuxGate_28056
* NET  9355 = abc_29733_auto_rtlil_cc_2560_MuxGate_28054
* NET  9356 = abc_29733_auto_rtlil_cc_2560_MuxGate_28052
* NET  9357 = abc_29733_auto_rtlil_cc_2560_MuxGate_28050
* NET  9358 = abc_29733_auto_rtlil_cc_2560_MuxGate_28048
* NET  9359 = abc_29733_auto_rtlil_cc_2560_MuxGate_28046
* NET  9360 = abc_29733_auto_rtlil_cc_2560_MuxGate_28044
* NET  9361 = abc_29733_auto_rtlil_cc_2560_MuxGate_28042
* NET  9362 = abc_29733_auto_rtlil_cc_2560_MuxGate_28040
* NET  9363 = abc_29733_auto_rtlil_cc_2560_MuxGate_28038
* NET  9364 = abc_29733_auto_rtlil_cc_2560_MuxGate_28036
* NET  9365 = abc_29733_auto_rtlil_cc_2560_MuxGate_28034
* NET  9366 = abc_29733_auto_rtlil_cc_2560_MuxGate_28032
* NET  9367 = abc_29733_auto_rtlil_cc_2560_MuxGate_28030
* NET  9368 = abc_29733_auto_rtlil_cc_2560_MuxGate_28028
* NET  9369 = abc_29733_auto_rtlil_cc_2560_MuxGate_28026
* NET  9370 = abc_29733_auto_rtlil_cc_2560_MuxGate_28024
* NET  9371 = abc_29733_auto_rtlil_cc_2560_MuxGate_28022
* NET  9372 = abc_29733_auto_rtlil_cc_2560_MuxGate_28020
* NET  9373 = abc_29733_auto_rtlil_cc_2560_MuxGate_28018
* NET  9374 = abc_29733_auto_rtlil_cc_2560_MuxGate_28016
* NET  9375 = abc_29733_auto_rtlil_cc_2560_MuxGate_28014
* NET  9376 = abc_29733_auto_rtlil_cc_2560_MuxGate_28012
* NET  9377 = abc_29733_auto_rtlil_cc_2560_MuxGate_28010
* NET  9378 = abc_29733_auto_rtlil_cc_2560_MuxGate_28008
* NET  9379 = abc_29733_auto_rtlil_cc_2560_MuxGate_28004
* NET  9380 = abc_29733_auto_rtlil_cc_2560_MuxGate_28000
* NET  9381 = abc_29733_auto_rtlil_cc_2560_MuxGate_27996
* NET  9382 = abc_29733_auto_rtlil_cc_2560_MuxGate_27994
* NET  9383 = abc_29733_auto_rtlil_cc_2560_MuxGate_27992
* NET  9384 = abc_29733_auto_rtlil_cc_2560_MuxGate_27990
* NET  9385 = abc_29733_auto_rtlil_cc_2560_MuxGate_27988
* NET  9386 = abc_29733_auto_rtlil_cc_2560_MuxGate_27986
* NET  9387 = abc_29733_auto_rtlil_cc_2560_MuxGate_27984
* NET  9388 = abc_29733_auto_rtlil_cc_2560_MuxGate_27982
* NET  9389 = abc_29733_auto_rtlil_cc_2560_MuxGate_27980
* NET  9390 = abc_29733_auto_rtlil_cc_2560_MuxGate_27978
* NET  9391 = abc_29733_auto_rtlil_cc_2560_MuxGate_27976
* NET  9392 = abc_29733_auto_rtlil_cc_2560_MuxGate_27974
* NET  9393 = abc_29733_auto_rtlil_cc_2560_MuxGate_27972
* NET  9394 = abc_29733_auto_rtlil_cc_2560_MuxGate_27970
* NET  9395 = abc_29733_auto_rtlil_cc_2560_MuxGate_27968
* NET  9396 = abc_29733_auto_rtlil_cc_2560_MuxGate_27966
* NET  9397 = abc_29733_auto_rtlil_cc_2560_MuxGate_27964
* NET  9398 = abc_29733_auto_rtlil_cc_2560_MuxGate_27962
* NET  9399 = abc_29733_auto_rtlil_cc_2560_MuxGate_27960
* NET  9400 = abc_29733_auto_rtlil_cc_2560_MuxGate_27958
* NET  9401 = abc_29733_auto_rtlil_cc_2560_MuxGate_27956
* NET  9402 = abc_29733_auto_rtlil_cc_2560_MuxGate_27954
* NET  9403 = abc_29733_auto_rtlil_cc_2560_MuxGate_27952
* NET  9404 = abc_29733_auto_rtlil_cc_2560_MuxGate_27950
* NET  9405 = abc_29733_auto_rtlil_cc_2560_MuxGate_27948
* NET  9406 = abc_29733_auto_rtlil_cc_2560_MuxGate_27946
* NET  9407 = abc_29733_auto_rtlil_cc_2560_MuxGate_27944
* NET  9408 = abc_29733_auto_rtlil_cc_2560_MuxGate_27942
* NET  9409 = abc_29733_auto_rtlil_cc_2560_MuxGate_27940
* NET  9410 = abc_29733_auto_rtlil_cc_2560_MuxGate_27938
* NET  9411 = abc_29733_auto_rtlil_cc_2560_MuxGate_27936
* NET  9412 = abc_29733_auto_rtlil_cc_2560_MuxGate_27934
* NET  9413 = abc_29733_auto_rtlil_cc_2560_MuxGate_27932
* NET  9414 = abc_29733_auto_rtlil_cc_2560_MuxGate_27928
* NET  9415 = abc_29733_auto_rtlil_cc_2560_MuxGate_27924
* NET  9416 = abc_29733_auto_rtlil_cc_2560_MuxGate_27920
* NET  9417 = abc_29733_auto_rtlil_cc_2560_MuxGate_27916
* NET  9418 = abc_29733_auto_rtlil_cc_2560_MuxGate_27914
* NET  9419 = abc_29733_auto_rtlil_cc_2560_MuxGate_27912
* NET  9420 = abc_29733_auto_rtlil_cc_2560_MuxGate_27910
* NET  9421 = abc_29733_auto_rtlil_cc_2560_MuxGate_27908
* NET  9422 = abc_29733_auto_rtlil_cc_2560_MuxGate_27906
* NET  9423 = abc_29733_auto_rtlil_cc_2560_MuxGate_27904
* NET  9424 = abc_29733_auto_rtlil_cc_2560_MuxGate_27902
* NET  9425 = abc_29733_auto_rtlil_cc_2560_MuxGate_27900
* NET  9426 = abc_29733_auto_rtlil_cc_2560_MuxGate_27898
* NET  9427 = abc_29733_auto_rtlil_cc_2560_MuxGate_27896
* NET  9428 = abc_29733_auto_rtlil_cc_2560_MuxGate_27894
* NET  9429 = abc_29733_auto_rtlil_cc_2560_MuxGate_27892
* NET  9430 = abc_29733_auto_rtlil_cc_2560_MuxGate_27890
* NET  9431 = abc_29733_auto_rtlil_cc_2560_MuxGate_27888
* NET  9432 = abc_29733_auto_rtlil_cc_2560_MuxGate_27886
* NET  9433 = abc_29733_auto_rtlil_cc_2560_MuxGate_27884
* NET  9434 = abc_29733_auto_rtlil_cc_2560_MuxGate_27882
* NET  9435 = abc_29733_auto_rtlil_cc_2560_MuxGate_27880
* NET  9436 = abc_29733_auto_rtlil_cc_2560_MuxGate_27878
* NET  9437 = abc_29733_auto_rtlil_cc_2560_MuxGate_27876
* NET  9438 = abc_29733_auto_rtlil_cc_2560_MuxGate_27874
* NET  9439 = abc_29733_auto_rtlil_cc_2560_MuxGate_27872
* NET  9440 = abc_29733_auto_rtlil_cc_2560_MuxGate_27870
* NET  9441 = abc_29733_auto_rtlil_cc_2560_MuxGate_27868
* NET  9442 = abc_29733_auto_rtlil_cc_2560_MuxGate_27866
* NET  9443 = abc_29733_auto_rtlil_cc_2560_MuxGate_27864
* NET  9444 = abc_29733_auto_rtlil_cc_2560_MuxGate_27862
* NET  9445 = abc_29733_auto_rtlil_cc_2560_MuxGate_27860
* NET  9446 = abc_29733_auto_rtlil_cc_2560_MuxGate_27858
* NET  9447 = abc_29733_auto_rtlil_cc_2560_MuxGate_27856
* NET  9448 = abc_29733_auto_rtlil_cc_2560_MuxGate_27854
* NET  9449 = abc_29733_auto_rtlil_cc_2560_MuxGate_27852
* NET  9450 = abc_29733_auto_rtlil_cc_2560_MuxGate_27850
* NET  9451 = abc_29733_auto_rtlil_cc_2560_MuxGate_27848
* NET  9452 = abc_29733_auto_rtlil_cc_2560_MuxGate_27846
* NET  9453 = abc_29733_auto_rtlil_cc_2560_MuxGate_27844
* NET  9454 = abc_29733_auto_rtlil_cc_2560_MuxGate_27842
* NET  9455 = abc_29733_auto_rtlil_cc_2560_MuxGate_27840
* NET  9456 = abc_29733_auto_rtlil_cc_2560_MuxGate_27838
* NET  9457 = abc_29733_auto_rtlil_cc_2560_MuxGate_27836
* NET  9458 = abc_29733_auto_rtlil_cc_2560_MuxGate_27834
* NET  9459 = abc_29733_auto_rtlil_cc_2560_MuxGate_27832
* NET  9460 = abc_29733_auto_rtlil_cc_2560_MuxGate_27830
* NET  9461 = abc_29733_auto_rtlil_cc_2560_MuxGate_27828
* NET  9462 = abc_29733_auto_rtlil_cc_2560_MuxGate_27826
* NET  9463 = abc_29733_auto_rtlil_cc_2560_MuxGate_27824
* NET  9464 = abc_29733_auto_rtlil_cc_2560_MuxGate_27822
* NET  9465 = abc_29733_auto_rtlil_cc_2560_MuxGate_27820
* NET  9466 = abc_29733_auto_rtlil_cc_2560_MuxGate_27818
* NET  9467 = abc_29733_auto_rtlil_cc_2560_MuxGate_27816
* NET  9468 = abc_29733_auto_rtlil_cc_2560_MuxGate_27814
* NET  9469 = abc_29733_auto_rtlil_cc_2560_MuxGate_27812
* NET  9470 = abc_29733_auto_rtlil_cc_2560_MuxGate_27810
* NET  9471 = abc_29733_auto_rtlil_cc_2560_MuxGate_27808
* NET  9472 = abc_29733_auto_rtlil_cc_2560_MuxGate_27806
* NET  9473 = abc_29733_auto_rtlil_cc_2560_MuxGate_27804
* NET  9474 = abc_29733_auto_rtlil_cc_2560_MuxGate_27802
* NET  9475 = abc_29733_auto_rtlil_cc_2560_MuxGate_27800
* NET  9476 = abc_29733_auto_rtlil_cc_2560_MuxGate_27798
* NET  9477 = abc_29733_auto_rtlil_cc_2560_MuxGate_27796
* NET  9478 = abc_29733_auto_rtlil_cc_2560_MuxGate_27794
* NET  9479 = abc_29733_auto_rtlil_cc_2560_MuxGate_27792
* NET  9480 = abc_29733_auto_rtlil_cc_2560_MuxGate_27790
* NET  9481 = abc_29733_auto_rtlil_cc_2560_MuxGate_27788
* NET  9482 = abc_29733_auto_rtlil_cc_2560_MuxGate_27786
* NET  9483 = abc_29733_auto_rtlil_cc_2560_MuxGate_27784
* NET  9484 = abc_29733_auto_rtlil_cc_2560_MuxGate_27782
* NET  9485 = abc_29733_auto_rtlil_cc_2560_MuxGate_27780
* NET  9486 = abc_29733_auto_rtlil_cc_2560_MuxGate_27778
* NET  9487 = abc_29733_auto_rtlil_cc_2560_MuxGate_27776
* NET  9488 = abc_29733_auto_rtlil_cc_2560_MuxGate_27774
* NET  9489 = abc_29733_auto_rtlil_cc_2560_MuxGate_27772
* NET  9490 = abc_29733_auto_rtlil_cc_2560_MuxGate_27770
* NET  9491 = abc_29733_auto_rtlil_cc_2560_MuxGate_27768
* NET  9492 = abc_29733_auto_rtlil_cc_2560_MuxGate_27766
* NET  9493 = abc_29733_auto_rtlil_cc_2560_MuxGate_27764
* NET  9494 = abc_29733_auto_rtlil_cc_2560_MuxGate_27762
* NET  9495 = abc_29733_auto_rtlil_cc_2560_MuxGate_27760
* NET  9496 = abc_29733_auto_rtlil_cc_2560_MuxGate_27758
* NET  9497 = abc_29733_auto_rtlil_cc_2560_MuxGate_27756
* NET  9498 = abc_29733_auto_rtlil_cc_2560_MuxGate_27754
* NET  9499 = abc_29733_auto_rtlil_cc_2560_MuxGate_27752
* NET  9500 = abc_29733_auto_rtlil_cc_2560_MuxGate_27750
* NET  9501 = abc_29733_auto_rtlil_cc_2560_MuxGate_27748
* NET  9502 = abc_29733_auto_rtlil_cc_2560_MuxGate_27746
* NET  9503 = abc_29733_auto_rtlil_cc_2560_MuxGate_27744
* NET  9504 = abc_29733_auto_rtlil_cc_2560_MuxGate_27742
* NET  9505 = abc_29733_auto_rtlil_cc_2560_MuxGate_27740
* NET  9506 = abc_29733_auto_rtlil_cc_2560_MuxGate_27738
* NET  9507 = abc_29733_auto_rtlil_cc_2560_MuxGate_27736
* NET  9508 = abc_29733_auto_rtlil_cc_2560_MuxGate_27734
* NET  9509 = abc_29733_auto_rtlil_cc_2560_MuxGate_27732
* NET  9510 = abc_29733_auto_rtlil_cc_2560_MuxGate_27730
* NET  9511 = abc_29733_auto_rtlil_cc_2560_MuxGate_27728
* NET  9512 = abc_29733_auto_rtlil_cc_2560_MuxGate_27726
* NET  9513 = abc_29733_auto_rtlil_cc_2560_MuxGate_27722
* NET  9514 = abc_29733_auto_rtlil_cc_2560_MuxGate_27718
* NET  9515 = abc_29733_auto_rtlil_cc_2560_MuxGate_27714
* NET  9516 = abc_29733_auto_rtlil_cc_2560_MuxGate_27710
* NET  9517 = abc_29733_auto_rtlil_cc_2560_MuxGate_27706
* NET  9518 = abc_29733_auto_rtlil_cc_2560_MuxGate_27702
* NET  9519 = abc_29733_auto_rtlil_cc_2560_MuxGate_27698
* NET  9520 = abc_29733_auto_rtlil_cc_2560_MuxGate_27694
* NET  9521 = abc_29733_auto_rtlil_cc_2560_MuxGate_27690
* NET  9522 = abc_29733_auto_rtlil_cc_2560_MuxGate_27686
* NET  9523 = abc_29733_auto_rtlil_cc_2560_MuxGate_27682
* NET  9524 = abc_29733_auto_rtlil_cc_2560_MuxGate_27678
* NET  9525 = abc_29733_auto_rtlil_cc_2560_MuxGate_27674
* NET  9526 = abc_29733_auto_rtlil_cc_2560_MuxGate_27670
* NET  9527 = abc_29733_auto_rtlil_cc_2560_MuxGate_27666
* NET  9528 = abc_29733_auto_rtlil_cc_2560_MuxGate_27662
* NET  9529 = abc_29733_auto_rtlil_cc_2560_MuxGate_27658
* NET  9530 = abc_29733_auto_rtlil_cc_2560_MuxGate_27654
* NET  9531 = abc_29733_auto_rtlil_cc_2560_MuxGate_27650
* NET  9532 = abc_29733_auto_rtlil_cc_2560_MuxGate_27646
* NET  9533 = abc_29733_auto_rtlil_cc_2560_MuxGate_27642
* NET  9534 = abc_29733_auto_rtlil_cc_2560_MuxGate_27638
* NET  9535 = abc_29733_auto_rtlil_cc_2560_MuxGate_27634
* NET  9536 = abc_29733_auto_rtlil_cc_2560_MuxGate_27630
* NET  9537 = abc_29733_auto_rtlil_cc_2560_MuxGate_27626
* NET  9538 = abc_29733_auto_rtlil_cc_2560_MuxGate_27622
* NET  9539 = abc_29733_auto_rtlil_cc_2560_MuxGate_27618
* NET  9540 = abc_29733_auto_rtlil_cc_2560_MuxGate_27614
* NET  9541 = abc_29733_auto_rtlil_cc_2560_MuxGate_27610
* NET  9542 = abc_29733_auto_rtlil_cc_2560_MuxGate_27606
* NET  9543 = abc_29733_auto_rtlil_cc_2560_MuxGate_27602
* NET  9544 = abc_29733_auto_rtlil_cc_2560_MuxGate_27598
* NET  9545 = abc_29733_auto_rtlil_cc_2560_MuxGate_27594
* NET  9546 = abc_29733_auto_rtlil_cc_2560_MuxGate_27590
* NET  9547 = abc_29733_auto_rtlil_cc_2560_MuxGate_27586
* NET  9548 = abc_29733_auto_rtlil_cc_2560_MuxGate_27582
* NET  9549 = abc_29733_auto_rtlil_cc_2560_MuxGate_27578
* NET  9550 = abc_29733_auto_rtlil_cc_2560_MuxGate_27574
* NET  9551 = abc_29733_auto_rtlil_cc_2560_MuxGate_27570
* NET  9552 = abc_29733_auto_rtlil_cc_2560_MuxGate_27566
* NET  9553 = abc_29733_auto_rtlil_cc_2560_MuxGate_27562
* NET  9554 = abc_29733_auto_rtlil_cc_2560_MuxGate_27558
* NET  9555 = abc_29733_auto_rtlil_cc_2560_MuxGate_27554
* NET  9556 = abc_29733_auto_rtlil_cc_2560_MuxGate_27550
* NET  9557 = abc_29733_auto_rtlil_cc_2560_MuxGate_27546
* NET  9558 = abc_29733_auto_rtlil_cc_2560_MuxGate_27542
* NET  9559 = abc_29733_auto_rtlil_cc_2560_MuxGate_27538
* NET  9560 = abc_29733_auto_rtlil_cc_2560_MuxGate_27534
* NET  9561 = abc_29733_auto_rtlil_cc_2560_MuxGate_27530
* NET  9562 = abc_29733_auto_rtlil_cc_2560_MuxGate_27526
* NET  9563 = abc_29733_auto_rtlil_cc_2560_MuxGate_27522
* NET  9564 = abc_29733_auto_rtlil_cc_2560_MuxGate_27518
* NET  9565 = abc_29733_auto_rtlil_cc_2560_MuxGate_27514
* NET  9566 = abc_29733_auto_rtlil_cc_2560_MuxGate_27510
* NET  9567 = abc_29733_auto_rtlil_cc_2560_MuxGate_27506
* NET  9568 = abc_29733_auto_rtlil_cc_2560_MuxGate_27502
* NET  9569 = abc_29733_auto_rtlil_cc_2560_MuxGate_27498
* NET  9570 = abc_29733_auto_rtlil_cc_2560_MuxGate_27494
* NET  9571 = abc_29733_auto_rtlil_cc_2560_MuxGate_27490
* NET  9572 = abc_29733_auto_rtlil_cc_2560_MuxGate_27486
* NET  9573 = abc_29733_auto_rtlil_cc_2560_MuxGate_27482
* NET  9574 = abc_29733_auto_rtlil_cc_2560_MuxGate_27478
* NET  9575 = abc_29733_auto_rtlil_cc_2560_MuxGate_27474
* NET  9576 = abc_29733_auto_rtlil_cc_2560_MuxGate_27470
* NET  9577 = abc_29733_auto_rtlil_cc_2560_MuxGate_27466
* NET  9578 = abc_29733_auto_rtlil_cc_2560_MuxGate_27462
* NET  9579 = abc_29733_auto_rtlil_cc_2560_MuxGate_27458
* NET  9580 = abc_29733_auto_rtlil_cc_2560_MuxGate_27454
* NET  9581 = abc_29733_auto_rtlil_cc_2560_MuxGate_27450
* NET  9582 = abc_29733_auto_rtlil_cc_2560_MuxGate_27446
* NET  9583 = abc_29733_auto_rtlil_cc_2560_MuxGate_27442
* NET  9584 = abc_29733_auto_rtlil_cc_2560_MuxGate_27438
* NET  9585 = abc_29733_auto_rtlil_cc_2560_MuxGate_27434
* NET  9586 = abc_29733_auto_rtlil_cc_2560_MuxGate_27430
* NET  9587 = abc_29733_auto_rtlil_cc_2560_MuxGate_27426
* NET  9588 = abc_29733_auto_rtlil_cc_2560_MuxGate_27422
* NET  9589 = abc_29733_auto_rtlil_cc_2560_MuxGate_27418
* NET  9590 = abc_29733_auto_rtlil_cc_2560_MuxGate_27414
* NET  9591 = abc_29733_auto_rtlil_cc_2560_MuxGate_27410
* NET  9592 = abc_29733_auto_rtlil_cc_2560_MuxGate_27406
* NET  9593 = abc_29733_auto_rtlil_cc_2560_MuxGate_27402
* NET  9594 = abc_29733_auto_rtlil_cc_2560_MuxGate_27398
* NET  9595 = abc_29733_auto_rtlil_cc_2560_MuxGate_27394
* NET  9596 = abc_29733_auto_rtlil_cc_2560_MuxGate_27390
* NET  9597 = abc_29733_auto_rtlil_cc_2560_MuxGate_27386
* NET  9598 = abc_29733_auto_rtlil_cc_2560_MuxGate_27382
* NET  9599 = abc_29733_auto_rtlil_cc_2560_MuxGate_27378
* NET  9600 = abc_29733_auto_rtlil_cc_2560_MuxGate_27374
* NET  9601 = abc_29733_auto_rtlil_cc_2560_MuxGate_27370
* NET  9602 = abc_29733_auto_rtlil_cc_2560_MuxGate_27366
* NET  9603 = abc_29733_auto_rtlil_cc_2560_MuxGate_27362
* NET  9604 = abc_29733_auto_rtlil_cc_2560_MuxGate_27358
* NET  9605 = abc_29733_auto_rtlil_cc_2560_MuxGate_27354
* NET  9606 = abc_29733_auto_rtlil_cc_2560_MuxGate_27350
* NET  9607 = abc_29733_auto_rtlil_cc_2560_MuxGate_27346
* NET  9608 = abc_29733_auto_rtlil_cc_2560_MuxGate_27342
* NET  9609 = abc_29733_auto_rtlil_cc_2560_MuxGate_27338
* NET  9610 = abc_29733_auto_rtlil_cc_2560_MuxGate_27334
* NET  9611 = abc_29733_auto_rtlil_cc_2560_MuxGate_27330
* NET  9612 = abc_29733_auto_rtlil_cc_2560_MuxGate_27326
* NET  9613 = abc_29733_auto_rtlil_cc_2560_MuxGate_27322
* NET  9614 = abc_29733_auto_rtlil_cc_2560_MuxGate_27318
* NET  9615 = abc_29733_auto_rtlil_cc_2560_MuxGate_27314
* NET  9616 = abc_29733_auto_rtlil_cc_2560_MuxGate_27310
* NET  9617 = abc_29733_auto_rtlil_cc_2560_MuxGate_27306
* NET  9618 = abc_29733_auto_rtlil_cc_2560_MuxGate_27302
* NET  9619 = abc_29733_auto_rtlil_cc_2560_MuxGate_27298
* NET  9620 = abc_29733_auto_rtlil_cc_2560_MuxGate_27294
* NET  9621 = abc_29733_auto_rtlil_cc_2560_MuxGate_27290
* NET  9622 = abc_29733_auto_rtlil_cc_2560_MuxGate_27286
* NET  9623 = abc_29733_auto_rtlil_cc_2560_MuxGate_27282
* NET  9624 = abc_29733_auto_rtlil_cc_2560_MuxGate_27278
* NET  9625 = abc_29733_auto_rtlil_cc_2560_MuxGate_27274
* NET  9626 = abc_29733_auto_rtlil_cc_2560_MuxGate_27270
* NET  9627 = abc_29733_auto_rtlil_cc_2560_MuxGate_27266
* NET  9628 = abc_29733_auto_rtlil_cc_2560_MuxGate_27262
* NET  9629 = abc_29733_auto_rtlil_cc_2560_MuxGate_27258
* NET  9630 = abc_29733_auto_rtlil_cc_2560_MuxGate_27254
* NET  9631 = abc_29733_auto_rtlil_cc_2560_MuxGate_27250
* NET  9632 = abc_29733_auto_rtlil_cc_2560_MuxGate_27246
* NET  9633 = abc_29733_auto_rtlil_cc_2560_MuxGate_27242
* NET  9634 = abc_29733_auto_rtlil_cc_2560_MuxGate_27238
* NET  9635 = abc_29733_auto_rtlil_cc_2560_MuxGate_27234
* NET  9636 = abc_29733_auto_rtlil_cc_2560_MuxGate_27230
* NET  9637 = abc_29733_auto_rtlil_cc_2560_MuxGate_27226
* NET  9638 = abc_29733_auto_rtlil_cc_2560_MuxGate_27222
* NET  9639 = abc_29733_auto_rtlil_cc_2560_MuxGate_27220
* NET  9640 = abc_29733_auto_rtlil_cc_2560_MuxGate_27218
* NET  9641 = abc_29733_auto_rtlil_cc_2560_MuxGate_27216
* NET  9642 = abc_29733_auto_rtlil_cc_2560_MuxGate_27214
* NET  9643 = abc_29733_auto_rtlil_cc_2560_MuxGate_27212
* NET  9644 = abc_29733_auto_rtlil_cc_2560_MuxGate_27210
* NET  9645 = abc_29733_auto_rtlil_cc_2560_MuxGate_27208
* NET  9646 = abc_29733_auto_rtlil_cc_2560_MuxGate_27206
* NET  9647 = abc_29733_auto_rtlil_cc_2560_MuxGate_27204
* NET  9648 = abc_29733_auto_rtlil_cc_2560_MuxGate_27202
* NET  9649 = abc_29733_auto_rtlil_cc_2560_MuxGate_27200
* NET  9650 = abc_29733_auto_rtlil_cc_2560_MuxGate_27198
* NET  9651 = abc_29733_auto_rtlil_cc_2560_MuxGate_27196
* NET  9652 = abc_29733_auto_rtlil_cc_2560_MuxGate_27194
* NET  9653 = abc_29733_auto_rtlil_cc_2560_MuxGate_27192
* NET  9654 = abc_29733_auto_rtlil_cc_2560_MuxGate_27190
* NET  9655 = abc_29733_auto_rtlil_cc_2560_MuxGate_27188
* NET  9656 = abc_29733_auto_rtlil_cc_2560_MuxGate_27186
* NET  9657 = abc_29733_auto_rtlil_cc_2560_MuxGate_27184
* NET  9658 = abc_29733_auto_rtlil_cc_2560_MuxGate_27182
* NET  9659 = abc_29733_auto_rtlil_cc_2560_MuxGate_27180
* NET  9660 = abc_29733_auto_rtlil_cc_2560_MuxGate_27178
* NET  9661 = abc_29733_auto_rtlil_cc_2560_MuxGate_27176
* NET  9662 = abc_29733_auto_rtlil_cc_2560_MuxGate_27174
* NET  9663 = abc_29733_auto_rtlil_cc_2560_MuxGate_27172
* NET  9664 = abc_29733_auto_rtlil_cc_2560_MuxGate_27170
* NET  9665 = abc_29733_auto_rtlil_cc_2560_MuxGate_27168
* NET  9666 = abc_29733_auto_rtlil_cc_2560_MuxGate_27166
* NET  9667 = abc_29733_auto_rtlil_cc_2560_MuxGate_27164
* NET  9668 = abc_29733_auto_rtlil_cc_2560_MuxGate_27162
* NET  9669 = abc_29733_auto_rtlil_cc_2560_MuxGate_27160
* NET  9670 = abc_29733_auto_rtlil_cc_2560_MuxGate_27158
* NET  9671 = abc_29733_auto_rtlil_cc_2560_MuxGate_27156
* NET  9672 = abc_29733_auto_rtlil_cc_2560_MuxGate_27154
* NET  9673 = abc_29733_auto_rtlil_cc_2560_MuxGate_27152
* NET  9674 = abc_29733_auto_rtlil_cc_2560_MuxGate_27150
* NET  9675 = abc_29733_auto_rtlil_cc_2560_MuxGate_27148
* NET  9676 = abc_29733_auto_rtlil_cc_2560_MuxGate_27146
* NET  9677 = abc_29733_auto_rtlil_cc_2560_MuxGate_27144
* NET  9678 = abc_29733_auto_rtlil_cc_2560_MuxGate_27142
* NET  9679 = abc_29733_auto_rtlil_cc_2560_MuxGate_27140
* NET  9680 = abc_29733_auto_rtlil_cc_2560_MuxGate_27138
* NET  9681 = abc_29733_auto_rtlil_cc_2560_MuxGate_27136
* NET  9682 = abc_29733_auto_rtlil_cc_2560_MuxGate_27134
* NET  9683 = abc_29733_auto_rtlil_cc_2560_MuxGate_27132
* NET  9684 = abc_29733_auto_rtlil_cc_2560_MuxGate_27130
* NET  9685 = abc_29733_auto_rtlil_cc_2560_MuxGate_27128
* NET  9686 = abc_29733_auto_rtlil_cc_2560_MuxGate_27126
* NET  9687 = abc_29733_auto_rtlil_cc_2560_MuxGate_27124
* NET  9688 = abc_29733_auto_rtlil_cc_2560_MuxGate_27122
* NET  9689 = abc_29733_auto_rtlil_cc_2560_MuxGate_27120
* NET  9690 = abc_29733_auto_rtlil_cc_2560_MuxGate_27118
* NET  9691 = abc_29733_auto_rtlil_cc_2560_MuxGate_27116
* NET  9692 = abc_29733_auto_rtlil_cc_2560_MuxGate_27114
* NET  9693 = abc_29733_auto_rtlil_cc_2560_MuxGate_27112
* NET  9694 = abc_29733_auto_rtlil_cc_2560_MuxGate_27110
* NET  9695 = abc_29733_auto_rtlil_cc_2560_MuxGate_27108
* NET  9696 = abc_29733_auto_rtlil_cc_2560_MuxGate_27106
* NET  9697 = abc_29733_auto_rtlil_cc_2560_MuxGate_27104
* NET  9698 = abc_29733_auto_rtlil_cc_2560_MuxGate_27102
* NET  9699 = abc_29733_auto_rtlil_cc_2560_MuxGate_27100
* NET  9700 = abc_29733_auto_rtlil_cc_2560_MuxGate_27098
* NET  9701 = abc_29733_auto_rtlil_cc_2560_MuxGate_27096
* NET  9702 = abc_29733_auto_rtlil_cc_2560_MuxGate_27094
* NET  9703 = abc_29733_auto_rtlil_cc_2560_MuxGate_27092
* NET  9704 = abc_29733_auto_rtlil_cc_2560_MuxGate_27090
* NET  9705 = abc_29733_auto_rtlil_cc_2560_MuxGate_27088
* NET  9706 = abc_29733_auto_rtlil_cc_2560_MuxGate_27086
* NET  9707 = abc_29733_auto_rtlil_cc_2560_MuxGate_27084
* NET  9708 = abc_29733_auto_rtlil_cc_2560_MuxGate_27082
* NET  9709 = abc_29733_auto_rtlil_cc_2560_MuxGate_27080
* NET  9710 = abc_29733_auto_rtlil_cc_2560_MuxGate_27078
* NET  9711 = abc_29733_auto_rtlil_cc_2560_MuxGate_27076
* NET  9712 = abc_29733_auto_rtlil_cc_2560_MuxGate_27074
* NET  9713 = abc_29733_auto_rtlil_cc_2560_MuxGate_27072
* NET  9714 = abc_29733_auto_rtlil_cc_2560_MuxGate_27070
* NET  9715 = abc_29733_auto_rtlil_cc_2560_MuxGate_27068
* NET  9716 = abc_29733_auto_rtlil_cc_2560_MuxGate_27066
* NET  9717 = abc_29733_auto_rtlil_cc_2560_MuxGate_27064
* NET  9718 = abc_29733_auto_rtlil_cc_2560_MuxGate_27062
* NET  9719 = abc_29733_auto_rtlil_cc_2560_MuxGate_27060
* NET  9720 = abc_29733_auto_rtlil_cc_2560_MuxGate_27058
* NET  9721 = abc_29733_auto_rtlil_cc_2560_MuxGate_27056
* NET  9722 = abc_29733_auto_rtlil_cc_2560_MuxGate_27054
* NET  9723 = abc_29733_auto_rtlil_cc_2560_MuxGate_27052
* NET  9724 = abc_29733_auto_rtlil_cc_2560_MuxGate_27050
* NET  9725 = abc_29733_auto_rtlil_cc_2560_MuxGate_27048
* NET  9726 = abc_29733_auto_rtlil_cc_2560_MuxGate_27046
* NET  9727 = abc_29733_auto_rtlil_cc_2560_MuxGate_27044
* NET  9728 = abc_29733_auto_rtlil_cc_2560_MuxGate_27042
* NET  9729 = abc_29733_auto_rtlil_cc_2560_MuxGate_27040
* NET  9730 = abc_29733_auto_rtlil_cc_2560_MuxGate_27038
* NET  9731 = abc_29733_auto_rtlil_cc_2560_MuxGate_27036
* NET  9732 = abc_29733_auto_rtlil_cc_2560_MuxGate_27034
* NET  9733 = abc_29733_auto_rtlil_cc_2560_MuxGate_27032
* NET  9734 = abc_29733_auto_rtlil_cc_2560_MuxGate_27030
* NET  9735 = abc_29733_auto_rtlil_cc_2560_MuxGate_27028
* NET  9736 = abc_29733_auto_rtlil_cc_2560_MuxGate_27026
* NET  9737 = abc_29733_auto_rtlil_cc_2560_MuxGate_27024
* NET  9738 = abc_29733_auto_rtlil_cc_2560_MuxGate_27022
* NET  9739 = abc_29733_auto_rtlil_cc_2560_MuxGate_27020
* NET  9740 = abc_29733_auto_rtlil_cc_2560_MuxGate_27018
* NET  9741 = abc_29733_auto_rtlil_cc_2560_MuxGate_27016
* NET  9742 = abc_29733_auto_rtlil_cc_2560_MuxGate_27014
* NET  9743 = abc_29733_auto_rtlil_cc_2560_MuxGate_27012
* NET  9744 = abc_29733_auto_rtlil_cc_2560_MuxGate_27010
* NET  9745 = abc_29733_auto_rtlil_cc_2560_MuxGate_27008
* NET  9746 = abc_29733_auto_rtlil_cc_2560_MuxGate_27006
* NET  9747 = abc_29733_auto_rtlil_cc_2560_MuxGate_27004
* NET  9748 = abc_29733_auto_rtlil_cc_2560_MuxGate_27002
* NET  9749 = abc_29733_auto_rtlil_cc_2560_MuxGate_27000
* NET  9750 = abc_29733_auto_rtlil_cc_2560_MuxGate_26998
* NET  9751 = abc_29733_auto_rtlil_cc_2560_MuxGate_26996
* NET  9752 = abc_29733_auto_rtlil_cc_2560_MuxGate_26994
* NET  9753 = abc_29733_auto_rtlil_cc_2560_MuxGate_26992
* NET  9754 = abc_29733_auto_rtlil_cc_2560_MuxGate_26990
* NET  9755 = abc_29733_auto_rtlil_cc_2560_MuxGate_26988
* NET  9756 = abc_29733_auto_rtlil_cc_2560_MuxGate_26986
* NET  9757 = abc_29733_auto_rtlil_cc_2560_MuxGate_26984
* NET  9758 = abc_29733_auto_rtlil_cc_2560_MuxGate_26982
* NET  9759 = abc_29733_auto_rtlil_cc_2560_MuxGate_26980
* NET  9760 = abc_29733_auto_rtlil_cc_2560_MuxGate_26978
* NET  9761 = abc_29733_auto_rtlil_cc_2560_MuxGate_26976
* NET  9762 = abc_29733_auto_rtlil_cc_2560_MuxGate_26974
* NET  9763 = abc_29733_auto_rtlil_cc_2560_MuxGate_26972
* NET  9764 = abc_29733_auto_rtlil_cc_2560_MuxGate_26970
* NET  9765 = abc_29733_auto_rtlil_cc_2560_MuxGate_26968
* NET  9766 = abc_29733_auto_rtlil_cc_2560_MuxGate_26966
* NET  9767 = abc_29733_auto_rtlil_cc_2560_MuxGate_26964
* NET  9768 = abc_29733_auto_rtlil_cc_2560_MuxGate_26962
* NET  9769 = abc_29733_auto_rtlil_cc_2560_MuxGate_26960
* NET  9770 = abc_29733_auto_rtlil_cc_2560_MuxGate_26958
* NET  9771 = abc_29733_auto_rtlil_cc_2560_MuxGate_26956
* NET  9772 = abc_29733_auto_rtlil_cc_2560_MuxGate_26954
* NET  9773 = abc_29733_auto_rtlil_cc_2560_MuxGate_26952
* NET  9774 = abc_29733_auto_rtlil_cc_2560_MuxGate_26950
* NET  9775 = abc_29733_auto_rtlil_cc_2560_MuxGate_26948
* NET  9776 = abc_29733_auto_rtlil_cc_2560_MuxGate_26946
* NET  9777 = abc_29733_auto_rtlil_cc_2560_MuxGate_26944
* NET  9778 = abc_29733_auto_rtlil_cc_2560_MuxGate_26942
* NET  9779 = abc_29733_auto_rtlil_cc_2560_MuxGate_26940
* NET  9780 = abc_29733_auto_rtlil_cc_2560_MuxGate_26938
* NET  9781 = abc_29733_auto_rtlil_cc_2560_MuxGate_26936
* NET  9782 = abc_29733_auto_rtlil_cc_2560_MuxGate_26934
* NET  9783 = abc_29733_auto_rtlil_cc_2560_MuxGate_26932
* NET  9784 = abc_29733_auto_rtlil_cc_2560_MuxGate_26930
* NET  9785 = abc_29733_auto_rtlil_cc_2560_MuxGate_26928
* NET  9786 = abc_29733_auto_rtlil_cc_2560_MuxGate_26926
* NET  9787 = abc_29733_auto_rtlil_cc_2560_MuxGate_26924
* NET  9788 = abc_29733_auto_rtlil_cc_2560_MuxGate_26922
* NET  9789 = abc_29733_auto_rtlil_cc_2560_MuxGate_26920
* NET  9790 = abc_29733_auto_rtlil_cc_2560_MuxGate_26918
* NET  9791 = abc_29733_auto_rtlil_cc_2560_MuxGate_26916
* NET  9792 = abc_29733_auto_rtlil_cc_2560_MuxGate_26914
* NET  9793 = abc_29733_auto_rtlil_cc_2560_MuxGate_26912
* NET  9794 = abc_29733_auto_rtlil_cc_2560_MuxGate_26910
* NET  9795 = abc_29733_auto_rtlil_cc_2560_MuxGate_26908
* NET  9796 = abc_29733_auto_rtlil_cc_2560_MuxGate_26906
* NET  9797 = abc_29733_auto_rtlil_cc_2560_MuxGate_26904
* NET  9798 = abc_29733_auto_rtlil_cc_2560_MuxGate_26902
* NET  9799 = abc_29733_auto_rtlil_cc_2560_MuxGate_26900
* NET  9800 = abc_29733_auto_rtlil_cc_2560_MuxGate_26898
* NET  9801 = abc_29733_auto_rtlil_cc_2560_MuxGate_26896
* NET  9802 = abc_29733_auto_rtlil_cc_2560_MuxGate_26894
* NET  9803 = abc_29733_auto_rtlil_cc_2560_MuxGate_26892
* NET  9804 = abc_29733_auto_rtlil_cc_2560_MuxGate_26890
* NET  9805 = abc_29733_auto_rtlil_cc_2560_MuxGate_26888
* NET  9806 = abc_29733_auto_rtlil_cc_2560_MuxGate_26886
* NET  9807 = abc_29733_auto_rtlil_cc_2560_MuxGate_26884
* NET  9808 = abc_29733_auto_rtlil_cc_2560_MuxGate_26882
* NET  9809 = abc_29733_auto_rtlil_cc_2560_MuxGate_26880
* NET  9810 = abc_29733_auto_rtlil_cc_2560_MuxGate_26878
* NET  9811 = abc_29733_auto_rtlil_cc_2560_MuxGate_26876
* NET  9812 = abc_29733_auto_rtlil_cc_2560_MuxGate_26874
* NET  9813 = abc_29733_auto_rtlil_cc_2560_MuxGate_26872
* NET  9814 = abc_29733_auto_rtlil_cc_2560_MuxGate_26870
* NET  9815 = abc_29733_auto_rtlil_cc_2560_MuxGate_26868
* NET  9816 = abc_29733_auto_rtlil_cc_2560_MuxGate_26866
* NET  9817 = abc_29733_auto_rtlil_cc_2560_MuxGate_26864
* NET  9818 = abc_29733_auto_rtlil_cc_2560_MuxGate_26862
* NET  9819 = abc_29733_auto_rtlil_cc_2560_MuxGate_26860
* NET  9820 = abc_29733_auto_rtlil_cc_2560_MuxGate_26858
* NET  9821 = abc_29733_auto_rtlil_cc_2560_MuxGate_26856
* NET  9822 = abc_29733_auto_rtlil_cc_2560_MuxGate_26854
* NET  9823 = abc_29733_auto_rtlil_cc_2560_MuxGate_26852
* NET  9824 = abc_29733_auto_rtlil_cc_2560_MuxGate_26850
* NET  9825 = abc_29733_auto_rtlil_cc_2560_MuxGate_26848
* NET  9826 = abc_29733_auto_rtlil_cc_2560_MuxGate_26846
* NET  9827 = abc_29733_auto_rtlil_cc_2560_MuxGate_26844
* NET  9828 = abc_29733_auto_rtlil_cc_2560_MuxGate_26842
* NET  9829 = abc_29733_auto_rtlil_cc_2560_MuxGate_26840
* NET  9830 = abc_29733_auto_rtlil_cc_2560_MuxGate_26838
* NET  9831 = abc_29733_auto_rtlil_cc_2560_MuxGate_26836
* NET  9832 = abc_29733_auto_rtlil_cc_2560_MuxGate_26834
* NET  9833 = abc_29733_auto_rtlil_cc_2560_MuxGate_26832
* NET  9834 = abc_29733_auto_rtlil_cc_2560_MuxGate_26830
* NET  9835 = abc_29733_auto_rtlil_cc_2560_MuxGate_26828
* NET  9836 = abc_29733_auto_rtlil_cc_2560_MuxGate_26826
* NET  9837 = abc_29733_auto_rtlil_cc_2560_MuxGate_26824
* NET  9838 = abc_29733_auto_rtlil_cc_2560_MuxGate_26822
* NET  9839 = abc_29733_auto_rtlil_cc_2560_MuxGate_26820
* NET  9840 = abc_29733_auto_rtlil_cc_2560_MuxGate_26818
* NET  9841 = abc_29733_auto_rtlil_cc_2560_MuxGate_26816
* NET  9842 = abc_29733_auto_rtlil_cc_2560_MuxGate_26814
* NET  9843 = abc_29733_auto_rtlil_cc_2560_MuxGate_26812
* NET  9844 = abc_29733_auto_rtlil_cc_2560_MuxGate_26810
* NET  9845 = abc_29733_auto_rtlil_cc_2560_MuxGate_26808
* NET  9846 = abc_29733_auto_rtlil_cc_2560_MuxGate_26806
* NET  9847 = abc_29733_auto_rtlil_cc_2560_MuxGate_26804
* NET  9848 = abc_29733_auto_rtlil_cc_2560_MuxGate_26802
* NET  9849 = abc_29733_auto_rtlil_cc_2560_MuxGate_26800
* NET  9850 = abc_29733_auto_rtlil_cc_2560_MuxGate_26798
* NET  9851 = abc_29733_auto_rtlil_cc_2560_MuxGate_26796
* NET  9852 = abc_29733_auto_rtlil_cc_2560_MuxGate_26794
* NET  9853 = abc_29733_auto_rtlil_cc_2560_MuxGate_26792
* NET  9854 = abc_29733_auto_rtlil_cc_2560_MuxGate_26790
* NET  9855 = abc_29733_auto_rtlil_cc_2560_MuxGate_26788
* NET  9856 = abc_29733_auto_rtlil_cc_2560_MuxGate_26786
* NET  9857 = abc_29733_auto_rtlil_cc_2560_MuxGate_26784
* NET  9858 = abc_29733_auto_rtlil_cc_2560_MuxGate_26782
* NET  9859 = abc_29733_auto_rtlil_cc_2560_MuxGate_26780
* NET  9860 = abc_29733_auto_rtlil_cc_2560_MuxGate_26778
* NET  9861 = abc_29733_auto_rtlil_cc_2560_MuxGate_26776
* NET  9862 = abc_29733_auto_rtlil_cc_2560_MuxGate_26774
* NET  9863 = abc_29733_auto_rtlil_cc_2560_MuxGate_26772
* NET  9864 = abc_29733_auto_rtlil_cc_2560_MuxGate_26770
* NET  9865 = abc_29733_auto_rtlil_cc_2560_MuxGate_26768
* NET  9866 = abc_29733_auto_rtlil_cc_2560_MuxGate_26766
* NET  9867 = abc_29733_auto_rtlil_cc_2560_MuxGate_26764
* NET  9868 = abc_29733_auto_rtlil_cc_2560_MuxGate_26762
* NET  9869 = abc_29733_auto_rtlil_cc_2560_MuxGate_26760
* NET  9870 = abc_29733_auto_rtlil_cc_2560_MuxGate_26758
* NET  9871 = abc_29733_auto_rtlil_cc_2560_MuxGate_26756
* NET  9872 = abc_29733_auto_rtlil_cc_2560_MuxGate_26754
* NET  9873 = abc_29733_auto_rtlil_cc_2560_MuxGate_26752
* NET  9874 = abc_29733_auto_rtlil_cc_2560_MuxGate_26750
* NET  9875 = abc_29733_auto_rtlil_cc_2560_MuxGate_26748
* NET  9876 = abc_29733_auto_rtlil_cc_2560_MuxGate_26746
* NET  9877 = abc_29733_auto_rtlil_cc_2560_MuxGate_26744
* NET  9878 = abc_29733_auto_rtlil_cc_2560_MuxGate_26742
* NET  9879 = abc_29733_auto_rtlil_cc_2560_MuxGate_26740
* NET  9880 = abc_29733_auto_rtlil_cc_2560_MuxGate_26738
* NET  9881 = abc_29733_auto_rtlil_cc_2560_MuxGate_26736
* NET  9882 = abc_29733_auto_rtlil_cc_2560_MuxGate_26734
* NET  9883 = abc_29733_auto_rtlil_cc_2560_MuxGate_26732
* NET  9884 = abc_29733_auto_rtlil_cc_2560_MuxGate_26730
* NET  9885 = abc_29733_auto_rtlil_cc_2560_MuxGate_26728
* NET  9886 = abc_29733_auto_rtlil_cc_2560_MuxGate_26726
* NET  9887 = abc_29733_auto_rtlil_cc_2560_MuxGate_26724
* NET  9888 = abc_29733_auto_rtlil_cc_2560_MuxGate_26722
* NET  9889 = abc_29733_auto_rtlil_cc_2560_MuxGate_26720
* NET  9890 = abc_29733_auto_rtlil_cc_2560_MuxGate_26718
* NET  9891 = abc_29733_auto_rtlil_cc_2560_MuxGate_26716
* NET  9892 = abc_29733_auto_rtlil_cc_2560_MuxGate_26714
* NET  9893 = abc_29733_auto_rtlil_cc_2560_MuxGate_26712
* NET  9894 = abc_29733_auto_rtlil_cc_2560_MuxGate_26710
* NET  9895 = abc_29733_auto_rtlil_cc_2560_MuxGate_26708
* NET  9896 = abc_29733_auto_rtlil_cc_2560_MuxGate_26706
* NET  9897 = abc_29733_auto_rtlil_cc_2560_MuxGate_26704
* NET  9898 = abc_29733_auto_rtlil_cc_2560_MuxGate_26702
* NET  9899 = abc_29733_auto_rtlil_cc_2560_MuxGate_26700
* NET  9900 = abc_29733_auto_rtlil_cc_2560_MuxGate_26698
* NET  9901 = abc_29733_auto_rtlil_cc_2560_MuxGate_26696
* NET  9902 = abc_29733_auto_rtlil_cc_2560_MuxGate_26694
* NET  9903 = abc_29733_auto_rtlil_cc_2560_MuxGate_26692
* NET  9904 = abc_29733_auto_rtlil_cc_2560_MuxGate_26690
* NET  9905 = abc_29733_auto_rtlil_cc_2560_MuxGate_26688
* NET  9906 = abc_29733_auto_rtlil_cc_2560_MuxGate_26686
* NET  9907 = abc_29733_auto_rtlil_cc_2560_MuxGate_26684
* NET  9908 = abc_29733_auto_rtlil_cc_2560_MuxGate_26682
* NET  9909 = abc_29733_auto_rtlil_cc_2560_MuxGate_26680
* NET  9910 = abc_29733_auto_rtlil_cc_2560_MuxGate_26678
* NET  9911 = abc_29733_auto_rtlil_cc_2560_MuxGate_26676
* NET  9912 = abc_29733_auto_rtlil_cc_2560_MuxGate_26674
* NET  9913 = abc_29733_auto_rtlil_cc_2560_MuxGate_26672
* NET  9914 = abc_29733_auto_rtlil_cc_2560_MuxGate_26670
* NET  9915 = abc_29733_auto_rtlil_cc_2560_MuxGate_26668
* NET  9916 = abc_29733_auto_rtlil_cc_2560_MuxGate_26666
* NET  9917 = abc_29733_auto_rtlil_cc_2560_MuxGate_26664
* NET  9918 = abc_29733_auto_rtlil_cc_2560_MuxGate_26662
* NET  9919 = abc_29733_auto_rtlil_cc_2560_MuxGate_26660
* NET  9920 = abc_29733_auto_rtlil_cc_2560_MuxGate_26658
* NET  9921 = abc_29733_auto_rtlil_cc_2560_MuxGate_26656
* NET  9922 = abc_29733_auto_rtlil_cc_2560_MuxGate_26654
* NET  9923 = abc_29733_auto_rtlil_cc_2560_MuxGate_26652
* NET  9924 = abc_29733_auto_rtlil_cc_2560_MuxGate_26650
* NET  9925 = abc_29733_auto_rtlil_cc_2560_MuxGate_26648
* NET  9926 = abc_29733_auto_rtlil_cc_2560_MuxGate_26646
* NET  9927 = abc_29733_auto_rtlil_cc_2560_MuxGate_26644
* NET  9928 = abc_29733_auto_rtlil_cc_2560_MuxGate_26642
* NET  9929 = abc_29733_auto_rtlil_cc_2560_MuxGate_26640
* NET  9930 = abc_29733_auto_rtlil_cc_2560_MuxGate_26638
* NET  9931 = abc_29733_auto_rtlil_cc_2560_MuxGate_26636
* NET  9932 = abc_29733_auto_rtlil_cc_2560_MuxGate_26634
* NET  9933 = abc_29733_auto_rtlil_cc_2560_MuxGate_26632
* NET  9934 = abc_29733_auto_rtlil_cc_2560_MuxGate_26630
* NET  9935 = abc_29733_auto_rtlil_cc_2560_MuxGate_26628
* NET  9936 = abc_29733_auto_rtlil_cc_2560_MuxGate_26626
* NET  9937 = abc_29733_auto_rtlil_cc_2560_MuxGate_26624
* NET  9938 = abc_29733_auto_rtlil_cc_2560_MuxGate_26622
* NET  9939 = abc_29733_auto_rtlil_cc_2560_MuxGate_26620
* NET  9940 = abc_29733_auto_rtlil_cc_2560_MuxGate_26618
* NET  9941 = abc_29733_auto_rtlil_cc_2560_MuxGate_26616
* NET  9942 = abc_29733_auto_rtlil_cc_2560_MuxGate_26614
* NET  9943 = abc_29733_auto_rtlil_cc_2560_MuxGate_26612
* NET  9944 = abc_29733_auto_rtlil_cc_2560_MuxGate_26610
* NET  9945 = abc_29733_auto_rtlil_cc_2560_MuxGate_26608
* NET  9946 = abc_29733_auto_rtlil_cc_2560_MuxGate_26606
* NET  9947 = abc_29733_auto_rtlil_cc_2560_MuxGate_26604
* NET  9948 = abc_29733_auto_rtlil_cc_2560_MuxGate_26602
* NET  9949 = abc_29733_auto_rtlil_cc_2560_MuxGate_26600
* NET  9950 = abc_29733_auto_rtlil_cc_2560_MuxGate_26598
* NET  9951 = abc_29733_auto_rtlil_cc_2560_MuxGate_26596
* NET  9952 = abc_29733_auto_rtlil_cc_2560_MuxGate_26594
* NET  9953 = abc_29733_auto_rtlil_cc_2560_MuxGate_26592
* NET  9954 = abc_29733_auto_rtlil_cc_2560_MuxGate_26590
* NET  9955 = abc_29733_auto_rtlil_cc_2560_MuxGate_26588
* NET  9956 = abc_29733_auto_rtlil_cc_2560_MuxGate_26586
* NET  9957 = abc_29733_auto_rtlil_cc_2560_MuxGate_26584
* NET  9958 = abc_29733_auto_rtlil_cc_2560_MuxGate_26582
* NET  9959 = abc_29733_auto_rtlil_cc_2560_MuxGate_26580
* NET  9960 = abc_29733_auto_rtlil_cc_2560_MuxGate_26578
* NET  9961 = abc_29733_auto_rtlil_cc_2560_MuxGate_26576
* NET  9962 = abc_29733_auto_rtlil_cc_2560_MuxGate_26574
* NET  9963 = abc_29733_auto_rtlil_cc_2560_MuxGate_26572
* NET  9964 = abc_29733_auto_rtlil_cc_2560_MuxGate_26570
* NET  9965 = abc_29733_auto_rtlil_cc_2560_MuxGate_26568
* NET  9966 = abc_29733_auto_rtlil_cc_2560_MuxGate_26566
* NET  9967 = abc_29733_auto_rtlil_cc_2560_MuxGate_26564
* NET  9968 = abc_29733_auto_rtlil_cc_2560_MuxGate_26562
* NET  9969 = abc_29733_auto_rtlil_cc_2560_MuxGate_26560
* NET  9970 = abc_29733_auto_rtlil_cc_2560_MuxGate_26558
* NET  9971 = abc_29733_auto_rtlil_cc_2560_MuxGate_26556
* NET  9972 = abc_29733_auto_rtlil_cc_2560_MuxGate_26554
* NET  9973 = abc_29733_auto_rtlil_cc_2560_MuxGate_26552
* NET  9974 = abc_29733_auto_rtlil_cc_2560_MuxGate_26550
* NET  9975 = abc_29733_auto_rtlil_cc_2560_MuxGate_26548
* NET  9976 = abc_29733_auto_rtlil_cc_2560_MuxGate_26546
* NET  9977 = abc_29733_auto_rtlil_cc_2560_MuxGate_26544
* NET  9978 = abc_29733_auto_rtlil_cc_2560_MuxGate_26542
* NET  9979 = abc_29733_auto_rtlil_cc_2560_MuxGate_26540
* NET  9980 = abc_29733_auto_rtlil_cc_2560_MuxGate_26538
* NET  9981 = abc_29733_auto_rtlil_cc_2560_MuxGate_26536
* NET  9982 = abc_29733_auto_rtlil_cc_2560_MuxGate_26534
* NET  9983 = abc_29733_auto_rtlil_cc_2560_MuxGate_26532
* NET  9984 = abc_29733_auto_rtlil_cc_2560_MuxGate_26530
* NET  9985 = abc_29733_auto_rtlil_cc_2560_MuxGate_26528
* NET  9986 = abc_29733_auto_rtlil_cc_2560_MuxGate_26526
* NET  9987 = abc_29733_auto_rtlil_cc_2560_MuxGate_26524
* NET  9988 = abc_29733_auto_rtlil_cc_2560_MuxGate_26522
* NET  9989 = abc_29733_auto_rtlil_cc_2560_MuxGate_26520
* NET  9990 = abc_29733_auto_rtlil_cc_2560_MuxGate_26518
* NET  9991 = abc_29733_auto_rtlil_cc_2560_MuxGate_26516
* NET  9992 = abc_29733_auto_rtlil_cc_2560_MuxGate_26514
* NET  9993 = abc_29733_auto_rtlil_cc_2560_MuxGate_26512
* NET  9994 = abc_29733_auto_rtlil_cc_2560_MuxGate_26510
* NET  9995 = abc_29733_auto_rtlil_cc_2560_MuxGate_26508
* NET  9996 = abc_29733_auto_rtlil_cc_2560_MuxGate_26506
* NET  9997 = abc_29733_auto_rtlil_cc_2560_MuxGate_26504
* NET  9998 = abc_29733_auto_rtlil_cc_2560_MuxGate_26502
* NET  9999 = abc_29733_auto_rtlil_cc_2560_MuxGate_26500
* NET 10000 = abc_29733_auto_rtlil_cc_2560_MuxGate_26498
* NET 10001 = abc_29733_auto_rtlil_cc_2560_MuxGate_26496
* NET 10002 = abc_29733_auto_rtlil_cc_2560_MuxGate_26494
* NET 10003 = abc_29733_auto_rtlil_cc_2560_MuxGate_26492
* NET 10004 = abc_29733_auto_rtlil_cc_2560_MuxGate_26490
* NET 10005 = abc_29733_auto_rtlil_cc_2560_MuxGate_26488
* NET 10006 = abc_29733_auto_rtlil_cc_2560_MuxGate_26486
* NET 10007 = abc_29733_auto_rtlil_cc_2560_MuxGate_26484
* NET 10008 = abc_29733_auto_rtlil_cc_2560_MuxGate_26482
* NET 10009 = abc_29733_auto_rtlil_cc_2560_MuxGate_26480
* NET 10010 = abc_29733_auto_rtlil_cc_2560_MuxGate_26478
* NET 10011 = abc_29733_auto_rtlil_cc_2560_MuxGate_26476
* NET 10012 = abc_29733_auto_rtlil_cc_2560_MuxGate_26474
* NET 10013 = abc_29733_auto_rtlil_cc_2560_MuxGate_26472
* NET 10014 = abc_29733_auto_rtlil_cc_2560_MuxGate_26470
* NET 10015 = abc_29733_auto_rtlil_cc_2560_MuxGate_26468
* NET 10016 = abc_29733_auto_rtlil_cc_2560_MuxGate_26466
* NET 10017 = abc_29733_auto_rtlil_cc_2560_MuxGate_26464
* NET 10018 = abc_29733_auto_rtlil_cc_2560_MuxGate_26462
* NET 10019 = abc_29733_auto_rtlil_cc_2560_MuxGate_26460
* NET 10020 = abc_29733_auto_rtlil_cc_2560_MuxGate_26458
* NET 10021 = abc_29733_auto_rtlil_cc_2560_MuxGate_26456
* NET 10022 = abc_29733_auto_rtlil_cc_2560_MuxGate_26454
* NET 10023 = abc_29733_auto_rtlil_cc_2560_MuxGate_26452
* NET 10024 = abc_29733_auto_rtlil_cc_2560_MuxGate_26450
* NET 10025 = abc_29733_auto_rtlil_cc_2560_MuxGate_26448
* NET 10026 = abc_29733_auto_rtlil_cc_2560_MuxGate_26446
* NET 10027 = abc_29733_auto_rtlil_cc_2560_MuxGate_26444
* NET 10028 = abc_29733_auto_rtlil_cc_2560_MuxGate_26442
* NET 10029 = abc_29733_auto_rtlil_cc_2560_MuxGate_26440
* NET 10030 = abc_29733_auto_rtlil_cc_2560_MuxGate_26438
* NET 10031 = abc_29733_auto_rtlil_cc_2560_MuxGate_26436
* NET 10032 = abc_29733_auto_rtlil_cc_2560_MuxGate_26434
* NET 10033 = abc_29733_auto_rtlil_cc_2560_MuxGate_26432
* NET 10034 = abc_29733_auto_rtlil_cc_2560_MuxGate_26430
* NET 10035 = abc_29733_auto_rtlil_cc_2560_MuxGate_26428
* NET 10036 = abc_29733_auto_rtlil_cc_2560_MuxGate_26426
* NET 10037 = abc_29733_auto_rtlil_cc_2560_MuxGate_26424
* NET 10038 = abc_29733_auto_rtlil_cc_2560_MuxGate_26422
* NET 10039 = abc_29733_auto_rtlil_cc_2560_MuxGate_26420
* NET 10040 = abc_29733_auto_rtlil_cc_2560_MuxGate_26418
* NET 10041 = abc_29733_auto_rtlil_cc_2560_MuxGate_26416
* NET 10042 = abc_29733_auto_rtlil_cc_2560_MuxGate_26414
* NET 10043 = abc_29733_auto_rtlil_cc_2560_MuxGate_26412
* NET 10044 = abc_29733_auto_rtlil_cc_2560_MuxGate_26410
* NET 10045 = abc_29733_auto_rtlil_cc_2560_MuxGate_26408
* NET 10046 = abc_29733_auto_rtlil_cc_2560_MuxGate_26406
* NET 10047 = abc_29733_auto_rtlil_cc_2560_MuxGate_26404
* NET 10048 = abc_29733_auto_rtlil_cc_2560_MuxGate_26402
* NET 10049 = abc_29733_auto_rtlil_cc_2560_MuxGate_26400
* NET 10050 = abc_29733_auto_rtlil_cc_2560_MuxGate_26398
* NET 10051 = abc_29733_auto_rtlil_cc_2560_MuxGate_26396
* NET 10052 = abc_29733_auto_rtlil_cc_2560_MuxGate_26394
* NET 10053 = abc_29733_auto_rtlil_cc_2560_MuxGate_26392
* NET 10054 = abc_29733_auto_rtlil_cc_2560_MuxGate_26390
* NET 10055 = abc_29733_auto_rtlil_cc_2560_MuxGate_26388
* NET 10056 = abc_29733_auto_rtlil_cc_2560_MuxGate_26386
* NET 10057 = abc_29733_auto_rtlil_cc_2560_MuxGate_26384
* NET 10058 = abc_29733_auto_rtlil_cc_2560_MuxGate_26382
* NET 10059 = abc_29733_auto_rtlil_cc_2560_MuxGate_26380
* NET 10060 = abc_29733_auto_rtlil_cc_2560_MuxGate_26378
* NET 10061 = abc_29733_auto_rtlil_cc_2560_MuxGate_26376
* NET 10062 = abc_29733_auto_rtlil_cc_2560_MuxGate_26374
* NET 10063 = abc_29733_auto_rtlil_cc_2560_MuxGate_26372
* NET 10064 = abc_29733_auto_rtlil_cc_2560_MuxGate_26370
* NET 10065 = abc_29733_auto_rtlil_cc_2560_MuxGate_26368
* NET 10066 = abc_29733_auto_rtlil_cc_2560_MuxGate_26366
* NET 10067 = abc_29733_auto_rtlil_cc_2560_MuxGate_26364
* NET 10068 = abc_29733_auto_rtlil_cc_2560_MuxGate_26362
* NET 10069 = abc_29733_auto_rtlil_cc_2560_MuxGate_26360
* NET 10070 = abc_29733_auto_rtlil_cc_2560_MuxGate_26358
* NET 10071 = abc_29733_auto_rtlil_cc_2560_MuxGate_26356
* NET 10072 = abc_29733_auto_rtlil_cc_2560_MuxGate_26354
* NET 10073 = abc_29733_auto_rtlil_cc_2560_MuxGate_26352
* NET 10074 = abc_29733_auto_rtlil_cc_2560_MuxGate_26350
* NET 10075 = abc_29733_auto_rtlil_cc_2560_MuxGate_26348
* NET 10076 = abc_29733_auto_rtlil_cc_2560_MuxGate_26346
* NET 10077 = abc_29733_auto_rtlil_cc_2560_MuxGate_26344
* NET 10078 = abc_29733_auto_rtlil_cc_2560_MuxGate_26342
* NET 10079 = abc_29733_auto_rtlil_cc_2560_MuxGate_26340
* NET 10080 = abc_29733_auto_rtlil_cc_2560_MuxGate_26338
* NET 10081 = abc_29733_auto_rtlil_cc_2560_MuxGate_26336
* NET 10082 = abc_29733_auto_rtlil_cc_2560_MuxGate_26334
* NET 10083 = abc_29733_auto_rtlil_cc_2560_MuxGate_26332
* NET 10084 = abc_29733_auto_rtlil_cc_2560_MuxGate_26330
* NET 10085 = abc_29733_auto_rtlil_cc_2560_MuxGate_26328
* NET 10086 = abc_19878_auto_rtlil_cc_2468_Mux_4438[4]
* NET 10087 = abc_19878_auto_rtlil_cc_2468_Mux_4438[3]
* NET 10088 = abc_19878_auto_rtlil_cc_2468_Mux_4438[2]
* NET 10089 = abc_19878_auto_rtlil_cc_2468_Mux_4438[1]
* NET 10090 = abc_19878_auto_rtlil_cc_2468_Mux_4438[0]
* NET 10091 = abc_19878_auto_rtlil_cc_2468_Mux_4435[4]
* NET 10092 = abc_19878_auto_rtlil_cc_2468_Mux_4435[3]
* NET 10093 = abc_19878_auto_rtlil_cc_2468_Mux_4435[2]
* NET 10094 = abc_19878_auto_rtlil_cc_2468_Mux_4435[1]
* NET 10095 = abc_19878_auto_rtlil_cc_2468_Mux_4435[0]
* NET 10096 = abc_19878_auto_fsm_map_cc_170_map_fsm_3975[2]
* NET 10097 = abc_19878_auto_fsm_map_cc_170_map_fsm_3975[1]
* NET 10098 = abc_19878_auto_fsm_map_cc_170_map_fsm_3975[0]
* NET 10099 = abc_19878_auto_fsm_map_cc_170_map_fsm_3774[6]
* NET 10100 = abc_19878_auto_fsm_map_cc_170_map_fsm_3774[5]
* NET 10101 = abc_19878_auto_fsm_map_cc_170_map_fsm_3774[4]
* NET 10102 = abc_19878_auto_fsm_map_cc_170_map_fsm_3774[3]
* NET 10103 = abc_19878_auto_fsm_map_cc_170_map_fsm_3774[2]
* NET 10104 = abc_19878_auto_fsm_map_cc_170_map_fsm_3774[1]
* NET 10105 = abc_19878_auto_fsm_map_cc_170_map_fsm_3774[0]

xsubckt_9715_sff1_x4 1 1872 0 8761 772 sff1_x4
xsubckt_8893_sff1_x4 1 1872 0 9500 1868 sff1_x4
xsubckt_8815_sff1_x4 1 1872 0 9578 1752 sff1_x4
xsubckt_8458_sff1_x4 1 1872 0 9935 728 sff1_x4
xsubckt_8370_sff1_x4 1 1872 0 10015 1547 sff1_x4
xsubckt_7363_nand3_x0 1 0 8050 8051 8076 8140 nand3_x0
xsubckt_7257_a3_x2 1 8127 0 373 7659 371 a3_x2
xsubckt_6973_mx2_x2 0 8325 1 712 1011 915 mx2_x2
xsubckt_6237_mx2_x2 0 2401 1 710 1412 1252 mx2_x2
xsubckt_6235_mx2_x2 0 2403 1 710 1732 900 mx2_x2
xsubckt_6233_mx2_x2 0 2405 1 710 1508 1348 mx2_x2
xsubckt_5634_a3_x2 1 2946 0 2951 1822 1823 a3_x2
xsubckt_4920_a3_x2 1 3545 0 40 76 7780 a3_x2
xsubckt_4805_nand4_x0 1 0 3632 3633 3634 3658 1786 nand4_x0
xsubckt_4129_a2_x2 0 3865 1 3869 46 a2_x2
xsubckt_3937_nand2_x0 1 0 4045 4046 4049 nand2_x0
xsubckt_3230_nand2_x0 1 0 4739 4740 4758 nand2_x0
xsubckt_1125_nand2_x0 1 0 6700 588 1799 nand2_x0
xsubckt_1035_nand2_x0 1 0 6786 588 1803 nand2_x0
xsubckt_1026_oa22_x2 0 6795 1 6843 6818 6819 oa22_x2
xsubckt_927_o2_x2 0 142 1 6890 6904 o2_x2
xsubckt_398_inv_x0 1 0 1172 7393 inv_x0
xsubckt_1389_nand3_x0 1 0 6450 6451 6452 6453 nand3_x0
xsubckt_2017_a2_x2 0 5851 1 6387 7788 a2_x2
xsubckt_2252_a2_x2 0 5699 1 7108 1739 a2_x2
xsubckt_9789_sff1_x4 1 1872 0 8687 1689 sff1_x4
xsubckt_9266_sff1_x4 1 1872 0 9195 523 sff1_x4
xsubckt_8889_sff1_x4 1 1872 0 9504 1810 sff1_x4
xsubckt_8366_sff1_x4 1 1872 0 10019 1553 sff1_x4
xsubckt_7619_a2_x2 0 7899 1 652 600 a2_x2
xsubckt_7385_a2_x2 0 8033 1 376 377 a2_x2
xsubckt_7345_a2_x2 0 8063 1 7670 353 a2_x2
xsubckt_7273_nand3_x0 1 0 8115 8117 7132 7194 nand3_x0
xsubckt_6944_ao22_x2 0 8353 1 8368 8356 8354 ao22_x2
xsubckt_6239_mx2_x2 0 2399 1 712 2400 2401 mx2_x2
xsubckt_6193_mx2_x2 0 2444 1 7625 7518 7520 mx2_x2
xsubckt_5952_nand2_x0 1 0 2680 2681 712 nand2_x0
xsubckt_5704_mx2_x2 0 2887 1 707 2888 2889 mx2_x2
xsubckt_5702_mx2_x2 0 2889 1 7217 7372 7376 mx2_x2
xsubckt_5507_nand4_x0 1 0 3038 3047 1861 1862 1863 nand4_x0
xsubckt_5164_ao22_x2 0 3342 1 600 3343 644 ao22_x2
xsubckt_4980_a3_x2 1 3500 0 40 69 7780 a3_x2
xsubckt_4960_a3_x2 1 3515 0 40 74 7780 a3_x2
xsubckt_4940_a3_x2 1 3530 0 40 49 7780 a3_x2
xsubckt_4842_nor3_x0 1 0 3603 3605 3631 7714 nor3_x0
xsubckt_4765_a3_x2 1 3662 0 3667 1789 1788 a3_x2
xsubckt_3904_a2_x2 0 4077 1 7153 7260 a2_x2
xsubckt_3475_a2_x2 0 4499 1 4500 7215 a2_x2
xsubckt_1302_nor2_x0 1 0 6533 683 58 nor2_x0
xsubckt_1363_a2_x2 0 6475 1 680 55 a2_x2
xsubckt_1660_ao22_x2 0 6181 1 6184 6190 6359 ao22_x2
xsubckt_1906_oa22_x2 0 1927 1 6111 5957 5953 oa22_x2
xsubckt_9697_sff1_x4 1 1872 0 8779 789 sff1_x4
xsubckt_9623_sff1_x4 1 1872 0 8850 861 sff1_x4
xsubckt_9100_sff1_x4 1 1872 0 1928 1896 sff1_x4
xsubckt_8723_sff1_x4 1 1872 0 9670 1288 sff1_x4
xsubckt_6979_mx2_x2 0 8319 1 710 1395 1235 mx2_x2
xsubckt_6744_nand2_x0 1 0 8549 8550 7631 nand2_x0
xsubckt_6495_ao22_x2 0 2149 1 7625 1310 2150 ao22_x2
xsubckt_5708_mx2_x2 0 2883 1 705 1199 1071 mx2_x2
xsubckt_5706_mx2_x2 0 2885 1 7217 7365 7369 mx2_x2
xsubckt_5595_nand4_x0 1 0 2974 2983 1834 1835 1836 nand4_x0
xsubckt_5587_a2_x2 0 2980 1 2983 1836 a2_x2
xsubckt_4833_a2_x2 0 3610 1 3613 1770 a2_x2
xsubckt_4520_mx3_x2 1 0 9748 3773 3896 1086 3835 3837 mx3_x2
xsubckt_3670_a2_x2 0 4307 1 4308 7217 a2_x2
xsubckt_3165_oa22_x2 0 4803 1 4804 4807 7218 oa22_x2
xsubckt_2913_ao22_x2 0 10076 1 5051 5098 5107 ao22_x2
xsubckt_1372_nand3_x0 1 0 6466 6467 6468 6469 nand3_x0
xsubckt_1606_xr2_x1 6235 0 1 197 227 xr2_x1
xsubckt_1677_a2_x2 0 6164 1 7230 213 a2_x2
xsubckt_9619_sff1_x4 1 1872 0 8854 865 sff1_x4
xsubckt_9531_sff1_x4 1 1872 0 8935 944 sff1_x4
xsubckt_9174_sff1_x4 1 1872 0 9284 611 sff1_x4
xsubckt_8797_sff1_x4 1 1872 0 9596 1771 sff1_x4
xsubckt_7432_nand4_x0 1 0 8017 8018 364 7679 644 nand4_x0
xsubckt_6564_nand2_x0 1 0 2081 2082 2087 nand2_x0
xsubckt_6404_o2_x2 0 2238 1 736 710 o2_x2
xsubckt_5221_o2_x2 0 3289 1 3290 3299 o2_x2
xsubckt_4698_a2_x2 0 3717 1 3727 3763 a2_x2
xsubckt_4526_mx3_x2 1 0 9742 3773 3896 1079 3817 3819 mx3_x2
xsubckt_4524_mx3_x2 1 0 9744 3773 3896 1081 3823 3825 mx3_x2
xsubckt_4522_mx3_x2 1 0 9746 3773 3896 1083 3829 3831 mx3_x2
xsubckt_4133_mx3_x2 1 0 10045 3899 3897 1577 3863 3864 mx3_x2
xsubckt_3789_a2_x2 0 4190 1 4191 7217 a2_x2
xsubckt_1564_xr2_x1 6277 0 1 445 229 xr2_x1
xsubckt_1989_nand3_x0 1 0 5876 5877 5878 5879 nand3_x0
xsubckt_9082_sff1_x4 1 1872 0 9344 524 sff1_x4
xsubckt_8719_sff1_x4 1 1872 0 9674 1107 sff1_x4
xsubckt_8631_sff1_x4 1 1872 0 9762 1070 sff1_x4
xsubckt_5086_o2_x2 0 9539 1 3414 3427 o2_x2
xsubckt_4528_mx3_x2 1 0 9740 3773 3896 1077 3811 3813 mx3_x2
xsubckt_4482_mx3_x2 1 0 9784 3775 3896 1474 3847 3849 mx3_x2
xsubckt_4480_mx3_x2 1 0 9786 3775 3896 1476 3853 3855 mx3_x2
xsubckt_4137_mx3_x2 1 0 10044 3899 3897 1606 3859 3860 mx3_x2
xsubckt_3740_nand2_x0 1 0 4238 4239 4240 nand2_x0
xsubckt_1129_ao22_x2 0 6696 1 6697 6701 7038 ao22_x2
xsubckt_851_nand3_x0 1 0 6962 6963 6964 1740 nand3_x0
xsubckt_1605_o2_x2 0 6236 1 197 227 o2_x2
xsubckt_9527_sff1_x4 1 1872 0 8939 949 sff1_x4
xsubckt_9004_sff1_x4 1 1872 0 9421 496 sff1_x4
xsubckt_6953_o2_x2 0 8345 1 8349 7628 o2_x2
xsubckt_6568_nor2_x0 1 0 2077 2078 7134 nor2_x0
xsubckt_6384_nand2_x0 1 0 2257 2258 2260 nand2_x0
xsubckt_6206_nand2_x0 1 0 2431 2432 2434 nand2_x0
xsubckt_5068_ao22_x2 0 3430 1 644 3537 7168 ao22_x2
xsubckt_4488_mx3_x2 1 0 9778 3775 3896 1467 3829 3831 mx3_x2
xsubckt_4486_mx3_x2 1 0 9780 3775 3896 1470 3835 3837 mx3_x2
xsubckt_4484_mx3_x2 1 0 9782 3775 3896 1472 3841 3843 mx3_x2
xsubckt_3912_o2_x2 0 4069 1 4070 4078 o2_x2
xsubckt_3397_nand2_x0 1 0 4575 7152 7264 nand2_x0
xsubckt_1796_oa22_x2 0 6052 1 7788 6056 6053 oa22_x2
xsubckt_9078_sff1_x4 1 1872 0 9348 1299 sff1_x4
xsubckt_8627_sff1_x4 1 1872 0 9766 1096 sff1_x4
xsubckt_8058_mx3_x2 1 0 8797 7808 3897 778 3867 3868 mx3_x2
xsubckt_7910_mx3_x2 1 0 8935 7818 3896 944 3799 3801 mx3_x2
xsubckt_6778_o2_x2 0 8516 1 1367 710 o2_x2
xsubckt_5234_nand2_x0 1 0 9527 3278 3288 nand2_x0
xsubckt_4183_nor4_x0 1 0 3824 3833 7739 7740 7741 nor4_x0
xsubckt_3822_nxr2_x1 4158 1 0 4160 4161 nxr2_x1
xsubckt_3431_mx2_x2 0 4542 1 705 1501 1341 mx2_x2
xsubckt_3039_nand2_x0 1 0 4927 4928 7219 nand2_x0
xsubckt_2247_nand2_x0 1 0 5704 5706 7613 nand2_x0
xsubckt_9870_sff1_x4 1 1872 0 8606 1611 sff1_x4
xsubckt_9435_sff1_x4 1 1872 0 9031 45 sff1_x4
xsubckt_7870_mx3_x2 1 0 8973 7820 3896 1175 3817 3819 mx3_x2
xsubckt_7564_ao22_x2 0 7942 1 607 594 356 ao22_x2
xsubckt_7001_mx2_x2 0 8298 1 710 1682 1554 mx2_x2
xsubckt_3957_mx3_x2 1 0 4025 707 705 4026 1523 1651 mx3_x2
xsubckt_3828_mx2_x2 0 4152 1 704 4153 4156 mx2_x2
xsubckt_3826_mx2_x2 0 4154 1 705 917 789 mx2_x2
xsubckt_3780_mx2_x2 0 4199 1 7218 4200 4202 mx2_x2
xsubckt_3435_mx2_x2 0 4538 1 7219 4539 4540 mx2_x2
xsubckt_3433_mx2_x2 0 4540 1 705 1725 893 mx2_x2
xsubckt_3102_ao22_x2 0 4865 1 7219 4866 7218 ao22_x2
xsubckt_749_a3_x2 1 7057 0 7112 7120 1738 a3_x2
xsubckt_1185_nand2_x0 1 0 160 6644 6655 nand2_x0
xsubckt_1269_oa22_x2 0 6564 1 6587 6582 6585 oa22_x2
xsubckt_1275_nand2_x0 1 0 6558 588 1790 nand2_x0
xsubckt_2368_ao22_x2 0 5586 1 652 5591 5590 ao22_x2
xsubckt_8970_sff1_x4 1 1872 0 155 92 sff1_x4
xsubckt_8535_sff1_x4 1 1872 0 9858 1486 sff1_x4
xsubckt_7874_mx3_x2 1 0 8969 7820 3896 1171 3805 3807 mx3_x2
xsubckt_7872_mx3_x2 1 0 8971 7820 3896 1173 3811 3813 mx3_x2
xsubckt_7743_mx2_x2 0 9124 1 7827 3886 1041 mx2_x2
xsubckt_7741_mx2_x2 0 9126 1 7827 3892 1063 mx2_x2
xsubckt_7007_mx2_x2 0 8292 1 710 722 1586 mx2_x2
xsubckt_6988_oa22_x2 0 8310 1 2729 8313 8311 oa22_x2
xsubckt_6229_ao22_x2 0 2409 1 2410 2412 7613 ao22_x2
xsubckt_5481_nand3_x0 1 0 3057 3063 1868 1869 nand3_x0
xsubckt_5130_a4_x2 0 3373 1 3407 3522 3525 3528 a4_x2
xsubckt_4879_nand2_x0 1 0 3575 3578 1758 nand2_x0
xsubckt_4221_a4_x2 0 3796 1 3902 7168 7212 522 a4_x2
xsubckt_3805_nand4_x0 1 0 4174 5604 532 7689 59 nand4_x0
xsubckt_3391_mx2_x2 0 4581 1 703 4582 4584 mx2_x2
xsubckt_3048_mx2_x2 0 4918 1 706 1060 964 mx2_x2
xsubckt_3046_mx2_x2 0 4920 1 706 1188 1124 mx2_x2
xsubckt_2900_mx2_x2 0 5063 1 706 5064 5066 mx2_x2
xsubckt_964_a3_x2 1 6854 0 6855 6856 6878 a3_x2
xsubckt_837_a2_x2 0 6975 1 207 1739 a2_x2
xsubckt_583_a2_x2 0 7208 1 344 343 a2_x2
xsubckt_240_inv_x0 1 0 778 7551 inv_x0
xsubckt_1626_oa22_x2 0 6215 1 6231 6229 6216 oa22_x2
xsubckt_2230_nand2_x0 1 0 5721 5723 5725 nand2_x0
xsubckt_9866_sff1_x4 1 1872 0 8610 1617 sff1_x4
xsubckt_9343_sff1_x4 1 1872 0 9118 1033 sff1_x4
xsubckt_8966_sff1_x4 1 1872 0 160 97 sff1_x4
xsubckt_8443_sff1_x4 1 1872 0 9950 714 sff1_x4
xsubckt_7876_mx3_x2 1 0 8967 7820 3896 1168 3799 3801 mx3_x2
xsubckt_7745_mx2_x2 0 9122 1 7827 3878 1037 mx2_x2
xsubckt_7009_mx2_x2 0 8290 1 710 1362 850 mx2_x2
xsubckt_5077_nxr2_x1 3422 1 0 3535 664 nxr2_x1
xsubckt_3788_mx2_x2 0 4191 1 707 1014 918 mx2_x2
xsubckt_3010_ao22_x2 0 4955 1 704 4956 5586 ao22_x2
xsubckt_897_a2_x2 0 6918 1 7143 1815 a2_x2
xsubckt_664_nand2_x0 1 0 7131 40 482 nand2_x0
xsubckt_610_nor2_x0 1 0 7181 7183 7184 nor2_x0
xsubckt_242_inv_x0 1 0 714 7549 inv_x0
xsubckt_244_inv_x0 1 0 1642 7547 inv_x0
xsubckt_246_inv_x0 1 0 1578 7545 inv_x0
xsubckt_2122_mx2_x2 0 438 1 7043 192 446 mx2_x2
xsubckt_2124_mx2_x2 0 436 1 7043 190 434 mx2_x2
xsubckt_2126_mx2_x2 0 433 1 7043 188 420 mx2_x2
xsubckt_2140_nand2_x0 1 0 5757 7044 179 nand2_x0
xsubckt_2276_ao22_x2 0 5676 1 5677 5688 708 ao22_x2
xsubckt_9774_sff1_x4 1 1872 0 8702 1675 sff1_x4
xsubckt_9700_sff1_x4 1 1872 0 8776 786 sff1_x4
xsubckt_9339_sff1_x4 1 1872 0 9122 1037 sff1_x4
xsubckt_8800_sff1_x4 1 1872 0 9593 1768 sff1_x4
xsubckt_6170_mx3_x2 1 0 2467 712 710 2468 7527 7529 mx3_x2
xsubckt_6000_a2_x2 0 2633 1 2634 2636 a2_x2
xsubckt_5484_a4_x2 0 3055 1 3063 1867 1868 1869 a4_x2
xsubckt_5434_nxr2_x1 3092 1 0 3454 665 nxr2_x1
xsubckt_4862_nand2_x0 1 0 3588 3591 1763 nand2_x0
xsubckt_4134_a3_x2 1 3861 0 3869 46 75 a3_x2
xsubckt_3529_ao22_x2 0 4446 1 4447 4449 4450 ao22_x2
xsubckt_3242_oa22_x2 0 4728 1 4830 4777 4729 oa22_x2
xsubckt_2866_mx2_x2 0 5097 1 705 1705 873 mx2_x2
xsubckt_1011_oa22_x2 0 6809 1 525 6899 6810 oa22_x2
xsubckt_248_inv_x0 1 0 1514 7543 inv_x0
xsubckt_1481_nxr2_x1 6360 1 0 188 217 nxr2_x1
xsubckt_2128_mx2_x2 0 431 1 7043 186 418 mx2_x2
xsubckt_9251_sff1_x4 1 1872 0 9210 327 sff1_x4
xsubckt_8874_sff1_x4 1 1872 0 9519 123 sff1_x4
xsubckt_8439_sff1_x4 1 1872 0 9954 718 sff1_x4
xsubckt_8351_sff1_x4 1 1872 0 10034 1595 sff1_x4
xsubckt_6045_mx2_x2 0 2589 1 710 746 1610 mx2_x2
xsubckt_5357_a3_x2 1 3163 0 3164 3168 3171 a3_x2
xsubckt_4829_a4_x2 0 3613 1 3622 1774 1772 1771 a4_x2
xsubckt_4603_a3_x2 1 3766 0 519 7210 521 a3_x2
xsubckt_4222_a2_x2 0 3795 1 3796 3907 a2_x2
xsubckt_3802_nand2_x0 1 0 4177 4178 4197 nand2_x0
xsubckt_2805_a3_x2 1 5156 0 5157 5158 5160 a3_x2
xsubckt_2577_nand2_x0 1 0 5380 5381 703 nand2_x0
xsubckt_823_nand3_x0 1 0 159 6989 6991 7004 nand3_x0
xsubckt_1193_a3_x2 1 6636 0 6638 6641 6660 a3_x2
xsubckt_1241_a2_x2 0 6590 1 215 1739 a2_x2
xsubckt_1642_a3_x2 1 6199 0 6200 6202 6330 a3_x2
xsubckt_1785_nand2_x0 1 0 6062 6114 6294 nand2_x0
xsubckt_2356_a3_x2 1 5598 0 5599 7153 1739 a3_x2
xsubckt_9682_sff1_x4 1 1872 0 8794 805 sff1_x4
xsubckt_9247_sff1_x4 1 1872 0 9214 332 sff1_x4
xsubckt_6726_oa22_x2 0 8567 1 709 8570 708 oa22_x2
xsubckt_6438_mx2_x2 0 2205 1 710 1023 831 mx2_x2
xsubckt_6392_mx2_x2 0 2250 1 710 2251 2252 mx2_x2
xsubckt_6390_mx2_x2 0 2252 1 712 1088 1056 mx2_x2
xsubckt_6266_nand2_x0 1 0 2373 2374 711 nand2_x0
xsubckt_5465_a2_x2 0 9505 1 3069 3070 a2_x2
xsubckt_4875_nor4_x0 1 0 3578 3581 3605 3631 7719 nor4_x0
xsubckt_3622_nand2_x0 1 0 4354 4355 4357 nand2_x0
xsubckt_3369_nand2_x0 1 0 4603 4604 4605 nand2_x0
xsubckt_3279_nand2_x0 1 0 4691 4692 7218 nand2_x0
xsubckt_1361_nor2_x0 1 0 6477 680 55 nor2_x0
xsubckt_1695_nand2_x0 1 0 6146 6147 6155 nand2_x0
xsubckt_9604_sff1_x4 1 1872 0 8869 872 sff1_x4
xsubckt_8782_sff1_x4 1 1872 0 9611 1788 sff1_x4
xsubckt_8347_sff1_x4 1 1872 0 10038 1600 sff1_x4
xsubckt_7772_a2_x2 0 7826 1 3900 3904 a2_x2
xsubckt_7311_nand2_x0 1 0 8089 8138 580 nand2_x0
xsubckt_6787_mx2_x2 0 8507 1 7625 7413 7415 mx2_x2
xsubckt_6396_mx2_x2 0 2246 1 710 1696 1568 mx2_x2
xsubckt_6176_nand2_x0 1 0 2461 2462 2463 nand2_x0
xsubckt_5303_oa22_x2 0 3214 1 3226 3222 3216 oa22_x2
xsubckt_5294_nand2_x0 1 0 3222 3224 3225 nand2_x0
xsubckt_4768_ao22_x2 0 3660 1 1787 3662 40 ao22_x2
xsubckt_4751_a2_x2 0 3673 1 3674 40 a2_x2
xsubckt_1025_xr2_x1 6796 0 1 698 73 xr2_x1
xsubckt_1192_ao22_x2 0 6637 1 6661 6639 6640 ao22_x2
xsubckt_1414_xr2_x1 6427 0 1 177 205 xr2_x1
xsubckt_2250_oa22_x2 0 5701 1 7648 529 1739 oa22_x2
xsubckt_2289_a2_x2 0 5663 1 5664 7613 a2_x2
xsubckt_9678_sff1_x4 1 1872 0 8798 779 sff1_x4
xsubckt_9590_sff1_x4 1 1872 0 8883 926 sff1_x4
xsubckt_9155_sff1_x4 1 1872 0 9303 602 sff1_x4
xsubckt_8704_sff1_x4 1 1872 0 9689 1123 sff1_x4
xsubckt_7085_oa22_x2 0 8216 1 975 710 712 oa22_x2
xsubckt_6118_nor2_x0 1 0 2517 2518 7134 nor2_x0
xsubckt_5867_mx2_x2 0 2760 1 711 1511 1447 mx2_x2
xsubckt_5779_a2_x2 0 2844 1 7065 7142 a2_x2
xsubckt_5377_oa22_x2 0 3145 1 3469 3472 7672 oa22_x2
xsubckt_3352_nand2_x0 1 0 4620 705 958 nand2_x0
xsubckt_2993_a2_x2 0 4972 1 4973 7217 a2_x2
xsubckt_2973_a2_x2 0 4992 1 705 7521 a2_x2
xsubckt_1637_ao22_x2 0 6204 1 6213 6212 6205 ao22_x2
xsubckt_1869_a2_x2 0 5986 1 5987 6224 a2_x2
xsubckt_2384_o3_x2 0 5570 1 5571 5573 704 o3_x2
xsubckt_9512_sff1_x4 1 1872 0 8954 965 sff1_x4
xsubckt_8778_sff1_x4 1 1872 0 9615 1792 sff1_x4
xsubckt_8690_sff1_x4 1 1872 0 9703 1423 sff1_x4
xsubckt_5869_mx2_x2 0 2758 1 711 1351 1287 mx2_x2
xsubckt_5218_nor2_x0 1 0 3292 3293 3294 nor2_x0
xsubckt_5211_oa22_x2 0 3299 1 7680 3502 7167 oa22_x2
xsubckt_4897_o4_x2 0 3561 1 3567 3631 7721 7722 o4_x2
xsubckt_4338_mx3_x2 1 0 9917 3786 3897 1513 3863 3864 mx3_x2
xsubckt_4336_mx3_x2 1 0 9919 3786 3897 1515 3871 3872 mx3_x2
xsubckt_4290_mx3_x2 1 0 9959 3792 3896 879 3797 3798 mx3_x2
xsubckt_4054_nand2_x0 1 0 3930 3931 707 nand2_x0
xsubckt_3341_o2_x2 0 4631 1 220 692 o2_x2
xsubckt_3262_nand2_x0 1 0 4708 4709 4713 nand2_x0
xsubckt_2706_o2_x2 0 5254 1 5255 7180 o2_x2
xsubckt_2688_nor2_x0 1 0 5271 5273 7216 nor2_x0
xsubckt_994_nand2_x0 1 0 6825 587 1770 nand2_x0
xsubckt_816_nand2_x0 1 0 6995 587 1779 nand2_x0
xsubckt_1543_o2_x2 0 6298 1 417 201 o2_x2
xsubckt_2202_nand2_x0 1 0 302 5749 7111 nand2_x0
xsubckt_9586_sff1_x4 1 1872 0 8887 930 sff1_x4
xsubckt_9508_sff1_x4 1 1872 0 8958 939 sff1_x4
xsubckt_9063_sff1_x4 1 1872 0 9363 1315 sff1_x4
xsubckt_8686_sff1_x4 1 1872 0 9707 1428 sff1_x4
xsubckt_8612_sff1_x4 1 1872 0 9781 1471 sff1_x4
xsubckt_8251_mx3_x2 1 0 8582 7798 3896 1615 3797 3798 mx3_x2
xsubckt_8120_mx2_x2 0 8707 1 7803 3890 1692 mx2_x2
xsubckt_5806_nand2_x0 1 0 2820 2821 2824 nand2_x0
xsubckt_5363_nand3_x0 1 0 3158 40 121 7780 nand3_x0
xsubckt_5207_oa22_x2 0 3302 1 7087 3303 3305 oa22_x2
xsubckt_3934_oa22_x2 0 4048 1 1075 705 707 oa22_x2
xsubckt_3870_o2_x2 0 4111 1 210 682 o2_x2
xsubckt_3655_o2_x2 0 4322 1 705 1656 o2_x2
xsubckt_3172_nand2_x0 1 0 4796 4797 4800 nand2_x0
xsubckt_1096_ao22_x2 0 6728 1 6754 6749 6731 ao22_x2
xsubckt_734_a4_x2 0 7069 1 7070 7072 7073 7075 a4_x2
xsubckt_726_nand2_x0 1 0 7077 7078 7083 nand2_x0
xsubckt_712_nand4_x0 1 0 7089 7124 7130 7135 7141 nand4_x0
xsubckt_2112_nand2_x0 1 0 5770 418 308 nand2_x0
xsubckt_9420_sff1_x4 1 1872 0 9046 1375 sff1_x4
xsubckt_9059_sff1_x4 1 1872 0 9367 1289 sff1_x4
xsubckt_8608_sff1_x4 1 1872 0 9785 1475 sff1_x4
xsubckt_8520_sff1_x4 1 1872 0 9873 986 sff1_x4
xsubckt_8124_mx2_x2 0 8703 1 7803 3874 1676 mx2_x2
xsubckt_8122_mx2_x2 0 8705 1 7803 3882 1678 mx2_x2
xsubckt_7720_mx3_x2 1 0 9145 7830 3896 1346 3847 3849 mx3_x2
xsubckt_6776_nand2_x0 1 0 8518 8519 711 nand2_x0
xsubckt_5677_nxr2_x1 2914 1 0 205 677 nxr2_x1
xsubckt_5406_ao22_x2 0 3118 1 600 3119 644 ao22_x2
xsubckt_5273_nand3_x0 1 0 3242 40 127 7780 nand3_x0
xsubckt_4834_nand2_x0 1 0 3609 3613 1770 nand2_x0
xsubckt_3699_nand2_x0 1 0 4278 7153 7264 nand2_x0
xsubckt_3610_ao22_x2 0 4366 1 7219 4367 703 ao22_x2
xsubckt_2511_oa22_x2 0 5445 1 1148 7217 5446 oa22_x2
xsubckt_1140_nand2_x0 1 0 6686 7143 1862 nand2_x0
xsubckt_1018_ao22_x2 0 6802 1 6803 6807 7038 ao22_x2
xsubckt_0_inv_x0 1 0 1740 7791 inv_x0
xsubckt_2_inv_x0 1 0 536 7789 inv_x0
xsubckt_4_inv_x0 1 0 525 7787 inv_x0
xsubckt_1696_nor2_x0 1 0 6145 6146 6166 nor2_x0
xsubckt_1937_nand2_x0 1 0 5924 6116 6361 nand2_x0
xsubckt_2022_nand2_x0 1 0 5846 5848 6390 nand2_x0
xsubckt_9851_sff1_x4 1 1872 0 8625 1243 sff1_x4
xsubckt_9494_sff1_x4 1 1872 0 8972 1174 sff1_x4
xsubckt_9416_sff1_x4 1 1872 0 9050 1379 sff1_x4
xsubckt_8594_sff1_x4 1 1872 0 9799 1007 sff1_x4
xsubckt_7726_mx3_x2 1 0 9139 7830 3896 1339 3829 3831 mx3_x2
xsubckt_7724_mx3_x2 1 0 9141 7830 3896 1342 3835 3837 mx3_x2
xsubckt_7722_mx3_x2 1 0 9143 7830 3896 1344 3841 3843 mx3_x2
xsubckt_5115_oa22_x2 0 3387 1 3401 3399 3400 oa22_x2
xsubckt_3331_nand3_x0 1 0 4640 4641 4786 5699 nand3_x0
xsubckt_6_inv_x0 1 0 526 7785 inv_x0
xsubckt_8_inv_x0 1 0 482 7783 inv_x0
xsubckt_2364_nor4_x0 1 0 5590 532 1739 1738 1737 nor4_x0
xsubckt_8951_sff1_x4 1 1872 0 145 82 sff1_x4
xsubckt_8516_sff1_x4 1 1872 0 9877 991 sff1_x4
xsubckt_8088_mx2_x2 0 8769 1 7805 3882 750 mx2_x2
xsubckt_8086_mx2_x2 0 8771 1 7805 3890 764 mx2_x2
xsubckt_8084_mx2_x2 0 8773 1 7805 3894 776 mx2_x2
xsubckt_7728_mx3_x2 1 0 9137 7830 3896 1337 3823 3825 mx3_x2
xsubckt_7545_ao22_x2 0 7958 1 607 594 352 ao22_x2
xsubckt_7022_ao22_x2 0 8277 1 534 532 680 ao22_x2
xsubckt_5314_ao22_x2 0 3204 1 3480 3483 665 ao22_x2
xsubckt_4057_ao22_x2 0 3927 1 3932 3930 3928 ao22_x2
xsubckt_3985_mx2_x2 0 3998 1 705 914 786 mx2_x2
xsubckt_3983_mx2_x2 0 4000 1 705 1426 1266 mx2_x2
xsubckt_3981_mx2_x2 0 4002 1 705 1490 1330 mx2_x2
xsubckt_3838_oa22_x2 0 4142 1 4143 705 7219 oa22_x2
xsubckt_3249_mx2_x2 0 4721 1 705 1696 1568 mx2_x2
xsubckt_2841_mx3_x2 1 0 5121 707 705 5122 7545 7549 mx3_x2
xsubckt_2802_nand2_x0 1 0 5159 7152 7276 nand2_x0
xsubckt_2710_mx2_x2 0 5250 1 705 1356 844 mx2_x2
xsubckt_2459_nand2_x0 1 0 5496 7218 1095 nand2_x0
xsubckt_715_a2_x2 0 7087 1 644 7690 a2_x2
xsubckt_441_inv_x0 1 0 1877 7350 inv_x0
xsubckt_9847_sff1_x4 1 1872 0 8629 1248 sff1_x4
xsubckt_9324_sff1_x4 1 1872 0 9137 1337 sff1_x4
xsubckt_7948_mx2_x2 0 8901 1 7813 3894 936 mx2_x2
xsubckt_7096_ao22_x2 0 8205 1 7360 710 712 ao22_x2
xsubckt_6645_ao22_x2 0 2002 1 2006 2005 2003 ao22_x2
xsubckt_6020_mx3_x2 1 0 2613 711 7620 2614 2626 2638 mx3_x2
xsubckt_5023_oa22_x2 0 9548 1 7168 3468 3470 oa22_x2
xsubckt_3989_mx2_x2 0 3994 1 705 1714 882 mx2_x2
xsubckt_3987_mx2_x2 0 3996 1 707 3997 3998 mx2_x2
xsubckt_3858_nand3_x0 1 0 4122 4123 4280 7104 nand3_x0
xsubckt_3453_xr2_x1 4521 0 1 217 689 xr2_x1
xsubckt_2712_mx2_x2 0 5248 1 707 5249 5250 mx2_x2
xsubckt_795_a2_x2 0 7015 1 1739 229 a2_x2
xsubckt_793_nand3_x0 1 0 7017 7018 7019 7020 nand3_x0
xsubckt_443_inv_x0 1 0 1876 7348 inv_x0
xsubckt_445_inv_x0 1 0 1875 7346 inv_x0
xsubckt_1830_nand2_x0 1 0 6021 6116 6311 nand2_x0
xsubckt_9398_sff1_x4 1 1872 0 10090 707 sff1_x4
xsubckt_8947_sff1_x4 1 1872 0 171 108 sff1_x4
xsubckt_8424_sff1_x4 1 1872 0 9969 890 sff1_x4
xsubckt_7611_oa22_x2 0 7906 1 644 7679 693 oa22_x2
xsubckt_6764_mx3_x2 1 0 8530 712 710 8532 7416 7418 mx3_x2
xsubckt_6196_ao22_x2 0 2441 1 1125 710 712 ao22_x2
xsubckt_5903_oa22_x2 0 2728 1 5746 5748 7081 oa22_x2
xsubckt_5616_a4_x2 0 2959 1 2967 1828 1829 1830 a4_x2
xsubckt_5296_ao22_x2 0 3220 1 3221 3223 3227 ao22_x2
xsubckt_5176_nand2_x0 1 0 3331 3511 7657 nand2_x0
xsubckt_5162_nand4_x0 1 0 3344 3373 3513 3516 3519 nand4_x0
xsubckt_5097_oa22_x2 0 3403 1 7102 3408 3404 oa22_x2
xsubckt_2718_mx2_x2 0 5242 1 705 1420 1260 mx2_x2
xsubckt_2614_ao22_x2 0 5344 1 1262 7217 7219 ao22_x2
xsubckt_447_inv_x0 1 0 1874 7344 inv_x0
xsubckt_449_inv_x0 1 0 1873 7342 inv_x0
xsubckt_1219_nand2_x0 1 0 6611 587 1758 nand2_x0
xsubckt_1397_nand2_x0 1 0 6443 6444 6445 nand2_x0
xsubckt_1740_nand2_x0 1 0 6102 6116 6277 nand2_x0
xsubckt_1792_ao22_x2 0 6056 1 6060 6294 6295 ao22_x2
xsubckt_2281_mx2_x2 0 5671 1 712 1553 1521 mx2_x2
xsubckt_9755_sff1_x4 1 1872 0 8721 1723 sff1_x4
xsubckt_9232_sff1_x4 1 1872 0 9229 329 sff1_x4
xsubckt_8498_sff1_x4 1 1872 0 9895 1519 sff1_x4
xsubckt_7449_ao22_x2 0 9241 1 8006 8004 8005 ao22_x2
xsubckt_6980_mx2_x2 0 8318 1 710 1491 1331 mx2_x2
xsubckt_6910_ao22_x2 0 8387 1 1460 710 712 ao22_x2
xsubckt_6633_mx2_x2 0 2014 1 710 1498 1338 mx2_x2
xsubckt_6553_ao22_x2 0 2092 1 2097 2095 2093 ao22_x2
xsubckt_6377_mx3_x2 1 0 2264 712 710 2265 1601 737 mx3_x2
xsubckt_6242_mx2_x2 0 2396 1 708 2397 2399 mx2_x2
xsubckt_6240_mx2_x2 0 2398 1 710 1028 836 mx2_x2
xsubckt_6037_a2_x2 0 2597 1 7543 710 a2_x2
xsubckt_5450_a3_x2 1 9509 0 3080 3081 40 a3_x2
xsubckt_5323_a2_x2 0 3195 1 3212 3477 a2_x2
xsubckt_5255_a3_x2 1 3258 0 3281 3492 3495 a3_x2
xsubckt_5019_oa22_x2 0 9549 1 7168 3471 3473 oa22_x2
xsubckt_3498_nand3_x0 1 0 4476 4477 5595 5608 nand3_x0
xsubckt_2678_mx2_x2 0 5281 1 705 1197 1069 mx2_x2
xsubckt_2676_mx2_x2 0 5283 1 705 1133 973 mx2_x2
xsubckt_1066_oa22_x2 0 166 1 6771 6770 6757 oa22_x2
xsubckt_1589_oa22_x2 0 6252 1 6260 6290 6291 oa22_x2
xsubckt_2254_a3_x2 1 5697 0 7108 7681 1739 a3_x2
xsubckt_2283_mx2_x2 0 5669 1 710 5670 5671 mx2_x2
xsubckt_2285_mx2_x2 0 5667 1 712 753 721 mx2_x2
xsubckt_2287_mx2_x2 0 5665 1 711 5666 5669 mx2_x2
xsubckt_2294_a3_x2 1 5658 0 5659 7108 1739 a3_x2
xsubckt_8855_sff1_x4 1 1872 0 9538 113 sff1_x4
xsubckt_8332_sff1_x4 1 1872 0 10053 1607 sff1_x4
xsubckt_7610_a2_x2 0 9177 1 7907 7911 a2_x2
xsubckt_7530_nand3_x0 1 0 7968 7168 658 7791 nand3_x0
xsubckt_7181_a2_x2 0 8158 1 3769 3796 a2_x2
xsubckt_6982_mx2_x2 0 8316 1 7631 8317 8318 mx2_x2
xsubckt_6379_mx3_x2 1 0 2262 7620 7613 2263 2268 2271 mx3_x2
xsubckt_5885_oa22_x2 0 2742 1 2761 2771 5744 oa22_x2
xsubckt_5711_mx2_x2 0 2880 1 7217 7359 7361 mx2_x2
xsubckt_5549_a3_x2 1 9482 0 3008 3009 40 a3_x2
xsubckt_3751_nand3_x0 1 0 4227 4228 4251 5586 nand3_x0
xsubckt_3545_a2_x2 0 4430 1 4431 707 a2_x2
xsubckt_3497_a3_x2 1 4477 0 4478 4480 4481 a3_x2
xsubckt_3131_oa22_x2 0 4836 1 4856 4844 4837 oa22_x2
xsubckt_2955_nand4_x0 1 0 5009 5604 532 7689 75 nand4_x0
xsubckt_2765_nor2_x0 1 0 5196 5197 707 nor2_x0
xsubckt_2537_xr2_x1 5419 0 1 218 690 xr2_x1
xsubckt_876_nand2_x0 1 0 6938 6939 7047 nand2_x0
xsubckt_1453_a2_x2 0 6388 1 182 211 a2_x2
xsubckt_1580_a3_x2 1 6261 0 6262 6268 6270 a3_x2
xsubckt_1750_mx2_x2 0 6093 1 574 6094 6273 mx2_x2
xsubckt_1854_a3_x2 1 5999 0 6000 6001 6002 a3_x2
xsubckt_1946_oa22_x2 0 5916 1 5917 5919 6366 oa22_x2
xsubckt_9663_sff1_x4 1 1872 0 8813 823 sff1_x4
xsubckt_9228_sff1_x4 1 1872 0 9233 344 sff1_x4
xsubckt_9140_sff1_x4 1 1872 0 9318 1143 sff1_x4
xsubckt_8763_sff1_x4 1 1872 0 9630 1746 sff1_x4
xsubckt_8328_sff1_x4 1 1872 0 10057 209 sff1_x4
xsubckt_6597_mx2_x2 0 2049 1 712 2050 2051 mx2_x2
xsubckt_6595_mx2_x2 0 2051 1 710 1467 1307 mx2_x2
xsubckt_6041_nand2_x0 1 0 2593 2594 711 nand2_x0
xsubckt_5717_mx2_x2 0 2874 1 7216 2884 2887 mx2_x2
xsubckt_5713_mx2_x2 0 2878 1 705 1455 1295 mx2_x2
xsubckt_5397_nxr2_x1 3126 1 0 3138 3463 nxr2_x1
xsubckt_5319_nxr2_x1 3199 1 0 3478 7672 nxr2_x1
xsubckt_2596_ao22_x2 0 10082 1 5364 5363 5362 ao22_x2
xsubckt_786_nand2_x0 1 0 7024 7025 7047 nand2_x0
xsubckt_696_nand2_x0 1 0 7105 7107 7683 nand2_x0
xsubckt_1298_a2_x2 0 6536 1 212 1739 a2_x2
xsubckt_1473_a2_x2 0 6368 1 187 216 a2_x2
xsubckt_1699_a3_x2 1 6142 0 6143 6430 605 a3_x2
xsubckt_1756_mx2_x2 0 6088 1 574 6091 6271 mx2_x2
xsubckt_2319_oa22_x2 0 5634 1 5635 5646 7613 oa22_x2
xsubckt_9659_sff1_x4 1 1872 0 8817 827 sff1_x4
xsubckt_9136_sff1_x4 1 1872 0 9322 1147 sff1_x4
xsubckt_7350_nand3_x0 1 0 8059 8060 8076 8133 nand3_x0
xsubckt_5776_nand2_x0 1 0 2847 2848 2849 nand2_x0
xsubckt_5231_nxr2_x1 3280 1 0 3298 3498 nxr2_x1
xsubckt_4533_mx3_x2 1 0 9735 3773 3896 1071 3797 3798 mx3_x2
xsubckt_4531_mx3_x2 1 0 9737 3773 3896 1074 3802 3804 mx3_x2
xsubckt_4400_mx2_x2 0 9862 1 3778 3894 1512 mx2_x2
xsubckt_4207_o2_x2 0 3806 1 3809 7747 o2_x2
xsubckt_3930_nor2_x0 1 0 4052 4053 4056 nor2_x0
xsubckt_2891_a2_x2 0 5072 1 5073 706 a2_x2
xsubckt_10_inv_x0 1 0 115 7781 inv_x0
xsubckt_12_inv_x0 1 0 116 7779 inv_x0
xsubckt_14_inv_x0 1 0 119 7777 inv_x0
xsubckt_1366_nxr2_x1 6472 1 0 6473 6479 nxr2_x1
xsubckt_2082_nand2_x0 1 0 5794 446 308 nand2_x0
xsubckt_9571_sff1_x4 1 1872 0 8902 1199 sff1_x4
xsubckt_8759_sff1_x4 1 1872 0 9634 1784 sff1_x4
xsubckt_8671_sff1_x4 1 1872 0 9722 1444 sff1_x4
xsubckt_8103_mx3_x2 1 0 8754 7806 3896 765 3832 3834 mx3_x2
xsubckt_8101_mx3_x2 1 0 8756 7806 3896 767 3838 3840 mx3_x2
xsubckt_7346_nand4_x0 1 0 8062 8063 8066 8078 8140 nand4_x0
xsubckt_5679_mx2_x2 0 2912 1 7217 7370 7374 mx2_x2
xsubckt_5227_nxr2_x1 3284 1 0 3499 652 nxr2_x1
xsubckt_5196_o2_x2 0 3312 1 3313 3322 o2_x2
xsubckt_4406_mx2_x2 0 9856 1 3778 3874 1484 mx2_x2
xsubckt_4404_mx2_x2 0 9858 1 3778 3882 1486 mx2_x2
xsubckt_4402_mx2_x2 0 9860 1 3778 3890 1500 mx2_x2
xsubckt_3744_nand2_x0 1 0 4234 4235 4238 nand2_x0
xsubckt_3064_o2_x2 0 4902 1 4903 706 o2_x2
xsubckt_16_inv_x0 1 0 121 7775 inv_x0
xsubckt_18_inv_x0 1 0 123 7773 inv_x0
xsubckt_1188_xr2_x1 6641 0 1 689 64 xr2_x1
xsubckt_9567_sff1_x4 1 1872 0 8906 1204 sff1_x4
xsubckt_9044_sff1_x4 1 1872 0 9382 178 sff1_x4
xsubckt_8109_mx3_x2 1 0 8748 7806 3896 758 3814 3816 mx3_x2
xsubckt_8107_mx3_x2 1 0 8750 7806 3896 760 3820 3822 mx3_x2
xsubckt_8105_mx3_x2 1 0 8752 7806 3896 762 3826 3828 mx3_x2
xsubckt_8061_mx3_x2 1 0 8794 7808 3897 805 3856 3857 mx3_x2
xsubckt_6399_o2_x2 0 2243 1 1664 710 o2_x2
xsubckt_4495_mx3_x2 1 0 9771 3775 3896 1460 3808 3810 mx3_x2
xsubckt_4493_mx3_x2 1 0 9773 3775 3896 1462 3814 3816 mx3_x2
xsubckt_4491_mx3_x2 1 0 9775 3775 3896 1464 3820 3822 mx3_x2
xsubckt_4408_mx2_x2 0 9854 1 3778 3866 1482 mx2_x2
xsubckt_3573_o2_x2 0 4402 1 4403 4410 o2_x2
xsubckt_2664_o2_x2 0 5295 1 705 1421 o2_x2
xsubckt_1286_o2_x2 0 6548 1 684 59 o2_x2
xsubckt_1762_oa22_x2 0 1913 1 6087 6086 6083 oa22_x2
xsubckt_9401_sff1_x4 1 1872 0 10087 704 sff1_x4
xsubckt_8667_sff1_x4 1 1872 0 9726 1418 sff1_x4
xsubckt_8067_mx3_x2 1 0 8788 7808 3896 799 3838 3840 mx3_x2
xsubckt_8065_mx3_x2 1 0 8790 7808 3896 801 3844 3846 mx3_x2
xsubckt_8063_mx3_x2 1 0 8792 7808 3896 803 3850 3852 mx3_x2
xsubckt_7618_ao22_x2 0 7900 1 607 594 369 ao22_x2
xsubckt_7343_nand2_x0 1 0 9284 8065 8068 nand2_x0
xsubckt_5100_oa22_x2 0 3401 1 3412 3409 3411 oa22_x2
xsubckt_4499_mx3_x2 1 0 9767 3775 3896 1455 3797 3798 mx3_x2
xsubckt_4497_mx3_x2 1 0 9769 3775 3896 1458 3802 3804 mx3_x2
xsubckt_4368_mx2_x2 0 9891 1 3781 3886 977 mx2_x2
xsubckt_4366_mx2_x2 0 9893 1 3781 3892 999 mx2_x2
xsubckt_3834_nor2_x0 1 0 4146 4147 4149 nor2_x0
xsubckt_3226_mx3_x2 1 0 4743 707 705 4744 1601 737 mx3_x2
xsubckt_3224_mx3_x2 1 0 4745 707 705 4746 1537 1665 mx3_x2
xsubckt_989_oa22_x2 0 6830 1 525 6899 6831 oa22_x2
xsubckt_1369_nand2_x0 1 0 6469 588 1785 nand2_x0
xsubckt_9475_sff1_x4 1 1872 0 8991 1164 sff1_x4
xsubckt_8501_sff1_x4 1 1872 0 9892 988 sff1_x4
xsubckt_8069_mx3_x2 1 0 8786 7808 3896 797 3832 3834 mx3_x2
xsubckt_7925_mx3_x2 1 0 8922 7816 3897 1221 3856 3857 mx3_x2
xsubckt_7923_mx3_x2 1 0 8924 7816 3897 1193 3863 3864 mx3_x2
xsubckt_7921_mx3_x2 1 0 8926 7816 3897 1195 3871 3872 mx3_x2
xsubckt_6519_oa22_x2 0 2126 1 40 1741 189 oa22_x2
xsubckt_6461_nand2_x0 1 0 2182 2183 7631 nand2_x0
xsubckt_5174_oa22_x2 0 3333 1 3339 3340 3341 oa22_x2
xsubckt_3835_mx2_x2 0 4145 1 704 1397 1109 mx2_x2
xsubckt_3384_nand2_x0 1 0 4588 4589 4590 nand2_x0
xsubckt_613_a2_x2 0 7178 1 7180 484 a2_x2
xsubckt_585_a3_x2 1 7206 0 344 343 482 a3_x2
xsubckt_1532_nand2_x0 1 0 6309 7239 199 nand2_x0
xsubckt_2043_oa22_x2 0 5827 1 6413 5837 5828 oa22_x2
xsubckt_9832_sff1_x4 1 1872 0 8644 1255 sff1_x4
xsubckt_8575_sff1_x4 1 1872 0 9818 1028 sff1_x4
xsubckt_7929_mx3_x2 1 0 8918 7816 3896 1217 3844 3846 mx3_x2
xsubckt_7927_mx3_x2 1 0 8920 7816 3896 1219 3850 3852 mx3_x2
xsubckt_7526_ao22_x2 0 7971 1 2857 2860 303 ao22_x2
xsubckt_7407_mx2_x2 0 9266 1 5752 9068 661 mx2_x2
xsubckt_7405_mx2_x2 0 9267 1 5752 9069 662 mx2_x2
xsubckt_7403_mx2_x2 0 9268 1 5752 9070 663 mx2_x2
xsubckt_7147_mx3_x2 1 0 9369 8167 3897 1291 3871 3872 mx3_x2
xsubckt_7014_mx2_x2 0 8285 1 712 8286 8287 mx2_x2
xsubckt_7012_mx2_x2 0 8287 1 710 1170 1042 mx2_x2
xsubckt_7010_mx2_x2 0 8289 1 710 1714 882 mx2_x2
xsubckt_7003_ao22_x2 0 8296 1 7620 8297 7613 ao22_x2
xsubckt_4797_oa22_x2 0 3638 1 3642 1780 1779 oa22_x2
xsubckt_4783_nand3_x0 1 0 3648 3650 3657 1786 nand3_x0
xsubckt_4167_nor3_x0 1 0 3836 3842 7736 7737 nor3_x0
xsubckt_3837_mx2_x2 0 4143 1 704 1237 949 mx2_x2
xsubckt_3770_nxr2_x1 4209 1 0 4210 4216 nxr2_x1
xsubckt_3057_mx2_x2 0 4909 1 705 1380 868 mx2_x2
xsubckt_3055_mx2_x2 0 4911 1 705 1028 836 mx2_x2
xsubckt_2931_nand3_x0 1 0 5033 5034 5038 703 nand3_x0
xsubckt_633_a2_x2 0 7159 1 7202 40 a2_x2
xsubckt_1442_nand2_x0 1 0 6399 184 213 nand2_x0
xsubckt_9828_sff1_x4 1 1872 0 8648 1650 sff1_x4
xsubckt_9383_sff1_x4 1 1872 0 9078 368 sff1_x4
xsubckt_8932_sff1_x4 1 1872 0 9461 1825 sff1_x4
xsubckt_7887_mx3_x2 1 0 8958 7818 3897 939 3871 3872 mx3_x2
xsubckt_7409_mx2_x2 0 9265 1 5752 9067 660 mx2_x2
xsubckt_7149_mx3_x2 1 0 9367 8167 3897 1289 3863 3864 mx3_x2
xsubckt_7069_nand3_x0 1 0 8231 8232 8256 2729 nand3_x0
xsubckt_7018_mx2_x2 0 8281 1 709 8282 8285 mx2_x2
xsubckt_7016_mx2_x2 0 8283 1 710 1490 1330 mx2_x2
xsubckt_6191_nand2_x0 1 0 2446 2447 7628 nand2_x0
xsubckt_6103_ao22_x2 0 2532 1 2537 2535 2533 ao22_x2
xsubckt_5838_nand2_x0 1 0 2788 2789 2808 nand2_x0
xsubckt_3650_xr2_x1 4327 0 1 214 686 xr2_x1
xsubckt_3138_ao22_x2 0 4830 1 4880 4834 4831 ao22_x2
xsubckt_3059_mx2_x2 0 4907 1 707 4908 4909 mx2_x2
xsubckt_2522_mx2_x2 0 5434 1 705 1692 1564 mx2_x2
xsubckt_251_inv_x0 1 0 873 7540 inv_x0
xsubckt_253_inv_x0 1 0 777 7538 inv_x0
xsubckt_1352_nand2_x0 1 0 6485 1814 589 nand2_x0
xsubckt_2144_nand2_x0 1 0 5755 7044 177 nand2_x0
xsubckt_9740_sff1_x4 1 1872 0 8736 1709 sff1_x4
xsubckt_9379_sff1_x4 1 1872 0 9082 372 sff1_x4
xsubckt_9305_sff1_x4 1 1872 0 9156 1329 sff1_x4
xsubckt_8928_sff1_x4 1 1872 0 9465 1830 sff1_x4
xsubckt_8840_sff1_x4 1 1872 0 9553 63 sff1_x4
xsubckt_8483_sff1_x4 1 1872 0 9910 1536 sff1_x4
xsubckt_8405_sff1_x4 1 1872 0 9988 892 sff1_x4
xsubckt_7889_mx3_x2 1 0 8956 7818 3897 937 3863 3864 mx3_x2
xsubckt_6858_oa22_x2 0 8438 1 8439 710 711 oa22_x2
xsubckt_4139_nxr2_x1 3857 1 0 3861 7731 nxr2_x1
xsubckt_1139_oa22_x2 0 6687 1 400 7044 6880 oa22_x2
xsubckt_1008_a3_x2 1 6812 0 389 307 229 a3_x2
xsubckt_921_nand2_x0 1 0 6895 588 1746 nand2_x0
xsubckt_255_inv_x0 1 0 1513 7536 inv_x0
xsubckt_257_inv_x0 1 0 1193 7534 inv_x0
xsubckt_259_inv_x0 1 0 1065 7532 inv_x0
xsubckt_1258_nand3_x0 1 0 6574 6575 6576 6577 nand3_x0
xsubckt_1969_nand2_x0 1 0 5895 6114 6380 nand2_x0
xsubckt_9736_sff1_x4 1 1872 0 8740 1735 sff1_x4
xsubckt_9291_sff1_x4 1 1872 0 9170 699 sff1_x4
xsubckt_9213_sff1_x4 1 1872 0 9245 646 sff1_x4
xsubckt_8479_sff1_x4 1 1872 0 9914 1540 sff1_x4
xsubckt_7666_oa22_x2 0 7860 1 644 7679 672 oa22_x2
xsubckt_7118_a2_x2 0 9381 1 8184 8227 a2_x2
xsubckt_6881_nand2_x0 1 0 8415 8416 7631 nand2_x0
xsubckt_6836_mx2_x2 0 8459 1 710 1366 854 mx2_x2
xsubckt_6834_mx2_x2 0 8461 1 712 8462 8463 mx2_x2
xsubckt_6832_mx2_x2 0 8463 1 710 1462 1302 mx2_x2
xsubckt_6441_mx2_x2 0 2202 1 710 1695 1567 mx2_x2
xsubckt_6052_mx2_x2 0 2582 1 710 1482 1322 mx2_x2
xsubckt_5958_oa22_x2 0 2674 1 7631 2675 711 oa22_x2
xsubckt_5870_oa22_x2 0 2757 1 2758 710 712 oa22_x2
xsubckt_5622_a3_x2 1 9462 0 2955 2956 40 a3_x2
xsubckt_5594_a4_x2 0 2975 1 2983 1834 1835 1836 a4_x2
xsubckt_5447_a3_x2 1 3082 0 1859 1870 1871 a3_x2
xsubckt_5435_oa22_x2 0 3091 1 3102 3093 3092 oa22_x2
xsubckt_4713_a3_x2 1 9623 0 3703 3705 40 a3_x2
xsubckt_3646_nor2_x0 1 0 4331 214 686 nor2_x0
xsubckt_3403_ao22_x2 0 4569 1 7180 4628 4570 ao22_x2
xsubckt_3335_a3_x2 1 4636 0 4637 4639 4640 a3_x2
xsubckt_1082_nand2_x0 1 0 6741 588 1801 nand2_x0
xsubckt_917_nand3_x0 1 0 6899 6900 6902 6903 nand3_x0
xsubckt_641_o2_x2 0 7154 1 577 578 o2_x2
xsubckt_1311_a2_x2 0 6524 1 7143 1852 a2_x2
xsubckt_9287_sff1_x4 1 1872 0 9174 695 sff1_x4
xsubckt_8836_sff1_x4 1 1872 0 9557 68 sff1_x4
xsubckt_8391_sff1_x4 1 1872 0 9994 1555 sff1_x4
xsubckt_8313_sff1_x4 1 1872 0 10072 225 sff1_x4
xsubckt_7607_a2_x2 0 7909 1 650 600 a2_x2
xsubckt_7353_a2_x2 0 8057 1 8060 8105 a2_x2
xsubckt_7178_a2_x2 0 8160 1 598 1737 a2_x2
xsubckt_7138_a2_x2 0 8167 1 3766 3900 a2_x2
xsubckt_6838_mx2_x2 0 8457 1 710 1174 1046 mx2_x2
xsubckt_6792_mx2_x2 0 8502 1 710 1143 983 mx2_x2
xsubckt_6703_nand2_x0 1 0 1945 1946 1948 nand2_x0
xsubckt_6449_mx2_x2 0 2194 1 710 1375 863 mx2_x2
xsubckt_6447_mx2_x2 0 2196 1 710 767 1631 mx2_x2
xsubckt_6444_a2_x2 0 2199 1 2200 2203 a2_x2
xsubckt_6249_a2_x2 0 9400 1 2390 2430 a2_x2
xsubckt_6058_mx2_x2 0 2576 1 712 2577 2578 mx2_x2
xsubckt_6056_mx2_x2 0 2578 1 710 1386 1226 mx2_x2
xsubckt_6054_mx2_x2 0 2580 1 710 1706 874 mx2_x2
xsubckt_5910_mx2_x2 0 2721 1 710 909 781 mx2_x2
xsubckt_3190_oa22_x2 0 4779 1 5595 5608 223 oa22_x2
xsubckt_3183_nand3_x0 1 0 4785 4786 4953 7104 nand3_x0
xsubckt_2477_nand4_x0 1 0 5478 5604 532 7689 76 nand4_x0
xsubckt_1176_a2_x2 0 6652 1 7143 1860 a2_x2
xsubckt_1439_nxr2_x1 6402 1 0 183 212 nxr2_x1
xsubckt_2065_a2_x2 0 5807 1 6143 574 a2_x2
xsubckt_9644_sff1_x4 1 1872 0 8832 813 sff1_x4
xsubckt_9209_sff1_x4 1 1872 0 9249 650 sff1_x4
xsubckt_9121_sff1_x4 1 1872 0 9337 1133 sff1_x4
xsubckt_8387_sff1_x4 1 1872 0 9998 1559 sff1_x4
xsubckt_7393_a2_x2 0 8026 1 7668 357 a2_x2
xsubckt_7315_nand2_x0 1 0 9290 8087 8088 nand2_x0
xsubckt_6523_nand2_x0 1 0 2122 2123 7631 nand2_x0
xsubckt_5914_mx2_x2 0 2717 1 710 1677 1549 mx2_x2
xsubckt_5912_mx2_x2 0 2719 1 712 2720 2721 mx2_x2
xsubckt_5817_nand3_x0 1 0 2809 2810 2813 7628 nand3_x0
xsubckt_5770_a2_x2 0 2853 1 40 536 a2_x2
xsubckt_5575_a2_x2 0 9475 1 2989 2990 a2_x2
xsubckt_4328_nand2_x0 1 0 3785 3787 3907 nand2_x0
xsubckt_1323_nor2_x0 1 0 6513 682 57 nor2_x0
xsubckt_1391_a2_x2 0 6448 1 206 1739 a2_x2
xsubckt_1645_a2_x2 0 6196 1 7223 221 a2_x2
xsubckt_1862_nand2_x0 1 0 5992 6116 6221 nand2_x0
xsubckt_1948_nand3_x0 1 0 5914 5915 5916 6111 nand3_x0
xsubckt_2359_a2_x2 0 5595 1 5596 5607 a2_x2
xsubckt_9195_sff1_x4 1 1872 0 9263 670 sff1_x4
xsubckt_8744_sff1_x4 1 1872 0 9649 1274 sff1_x4
xsubckt_8309_sff1_x4 1 1872 0 10076 199 sff1_x4
xsubckt_7051_oa22_x2 0 8249 1 7631 8254 711 oa22_x2
xsubckt_5874_mx2_x2 0 2753 1 711 1319 1255 mx2_x2
xsubckt_5872_mx2_x2 0 2755 1 711 1479 1415 mx2_x2
xsubckt_5298_nand2_x0 1 0 9522 3219 3231 nand2_x0
xsubckt_4341_mx3_x2 1 0 9914 3786 3896 1540 3853 3855 mx3_x2
xsubckt_1061_nand3_x0 1 0 6761 6762 6763 6764 nand3_x0
xsubckt_1347_nxr2_x1 6490 1 0 6492 6493 nxr2_x1
xsubckt_1427_xr2_x1 6414 0 1 180 209 xr2_x1
xsubckt_1685_a2_x2 0 6156 1 6157 6161 a2_x2
xsubckt_1772_nand2_x0 1 0 6074 6075 7788 nand2_x0
xsubckt_1835_oa22_x2 0 6017 1 6239 6315 7788 oa22_x2
xsubckt_9552_sff1_x4 1 1872 0 8921 1220 sff1_x4
xsubckt_9117_sff1_x4 1 1872 0 9341 1159 sff1_x4
xsubckt_7652_nand3_x0 1 0 7871 7872 7957 8140 nand3_x0
xsubckt_6873_ao22_x2 0 8423 1 1461 710 712 ao22_x2
xsubckt_6257_o2_x2 0 2382 1 2383 711 o2_x2
xsubckt_5878_mx2_x2 0 2749 1 710 1223 1095 mx2_x2
xsubckt_5774_oa22_x2 0 2849 1 2850 7075 7688 oa22_x2
xsubckt_5547_nand3_x0 1 0 3009 3015 1849 1850 nand3_x0
xsubckt_5328_o2_x2 0 9520 1 3191 3207 o2_x2
xsubckt_4755_nand3_x0 1 0 3670 3672 3676 3696 nand3_x0
xsubckt_4347_mx3_x2 1 0 9908 3786 3896 1534 3835 3837 mx3_x2
xsubckt_4345_mx3_x2 1 0 9910 3786 3896 1536 3841 3843 mx3_x2
xsubckt_4343_mx3_x2 1 0 9912 3786 3896 1538 3847 3849 mx3_x2
xsubckt_4214_mx2_x2 0 3801 1 518 84 1880 mx2_x2
xsubckt_4210_mx2_x2 0 3804 1 518 86 1882 mx2_x2
xsubckt_4058_nand2_x0 1 0 3926 3927 7218 nand2_x0
xsubckt_3543_oa22_x2 0 4432 1 922 706 705 oa22_x2
xsubckt_3451_o2_x2 0 4523 1 217 689 o2_x2
xsubckt_3216_o2_x2 0 4753 1 4754 4756 o2_x2
xsubckt_2474_nand2_x0 1 0 5481 7152 7294 nand2_x0
xsubckt_974_oa22_x2 0 6844 1 1737 6853 6845 oa22_x2
xsubckt_720_nand3_x0 1 0 7083 7096 7120 7195 nand3_x0
xsubckt_1678_nand3_x0 1 0 6163 6402 7230 213 nand3_x0
xsubckt_1704_nxr2_x1 6137 1 0 446 230 nxr2_x1
xsubckt_1979_a2_x2 0 5886 1 5887 6168 a2_x2
xsubckt_2120_oa22_x2 0 5763 1 7685 308 7245 oa22_x2
xsubckt_8652_sff1_x4 1 1872 0 9741 1078 sff1_x4
xsubckt_6066_nor2_x0 1 0 2568 2569 7134 nor2_x0
xsubckt_5988_nand2_x0 1 0 2645 1099 7625 nand2_x0
xsubckt_5501_nor3_x0 1 0 9495 3043 3044 7702 nor3_x0
xsubckt_5388_o2_x2 0 3134 1 3135 3146 o2_x2
xsubckt_4954_mx2_x2 0 3519 1 5753 3863 109 mx2_x2
xsubckt_4950_mx2_x2 0 3522 1 5753 3867 110 mx2_x2
xsubckt_4609_mx2_x2 0 9667 1 3764 3886 1265 mx2_x2
xsubckt_4607_mx2_x2 0 9669 1 3764 3892 1287 mx2_x2
xsubckt_4349_mx3_x2 1 0 9906 3786 3896 1531 3829 3831 mx3_x2
xsubckt_4218_mx2_x2 0 3798 1 518 83 1879 mx2_x2
xsubckt_4170_mx2_x2 0 3834 1 518 97 1893 mx2_x2
xsubckt_3974_oa22_x2 0 4009 1 4065 4060 4064 oa22_x2
xsubckt_1062_ao22_x2 0 6760 1 6761 6765 7038 ao22_x2
xsubckt_2116_nand2_x0 1 0 440 5767 5770 nand2_x0
xsubckt_2407_ao22_x2 0 5547 1 1544 7217 5548 ao22_x2
xsubckt_9548_sff1_x4 1 1872 0 8925 1194 sff1_x4
xsubckt_9460_sff1_x4 1 1872 0 9006 1400 sff1_x4
xsubckt_9025_sff1_x4 1 1872 0 9401 197 sff1_x4
xsubckt_8648_sff1_x4 1 1872 0 9745 1082 sff1_x4
xsubckt_6073_nand2_x0 1 0 2562 2563 7631 nand2_x0
xsubckt_4958_mx2_x2 0 3516 1 5753 3859 138 mx2_x2
xsubckt_4174_mx2_x2 0 3831 1 518 95 1891 mx2_x2
xsubckt_3423_mx3_x2 1 0 4550 704 7215 4551 4558 4560 mx3_x2
xsubckt_626_nand4_x0 1 0 7165 1737 593 40 7784 nand4_x0
xsubckt_2026_nand2_x0 1 0 5842 6112 6392 nand2_x0
xsubckt_9456_sff1_x4 1 1872 0 9010 1405 sff1_x4
xsubckt_9099_sff1_x4 1 1872 0 1929 1897 sff1_x4
xsubckt_8560_sff1_x4 1 1872 0 9833 1490 sff1_x4
xsubckt_7733_mx3_x2 1 0 9132 7830 3896 1332 3808 3810 mx3_x2
xsubckt_7731_mx3_x2 1 0 9134 7830 3896 1334 3814 3816 mx3_x2
xsubckt_7511_ao22_x2 0 7983 1 7042 7127 414 ao22_x2
xsubckt_4216_nxr2_x1 3799 1 0 3803 7749 nxr2_x1
xsubckt_4178_mx2_x2 0 3828 1 518 94 1890 mx2_x2
xsubckt_3815_nor2_x0 1 0 4165 211 683 nor2_x0
xsubckt_3774_mx3_x2 1 0 4205 707 705 4206 1046 1174 mx3_x2
xsubckt_3772_mx3_x2 1 0 4207 707 705 4208 950 1110 mx3_x2
xsubckt_3429_mx3_x2 1 0 4544 707 705 4545 1597 733 mx3_x2
xsubckt_1570_nor2_x0 1 0 6271 6272 6285 nor2_x0
xsubckt_2389_ao22_x2 0 5565 1 5566 5567 704 ao22_x2
xsubckt_9891_sff1_x4 1 1872 0 8585 1619 sff1_x4
xsubckt_9813_sff1_x4 1 1872 0 8663 1666 sff1_x4
xsubckt_8991_sff1_x4 1 1872 0 9434 510 sff1_x4
xsubckt_8556_sff1_x4 1 1872 0 9837 1494 sff1_x4
xsubckt_8093_mx2_x2 0 8764 1 7805 3862 745 mx2_x2
xsubckt_8091_mx2_x2 0 8766 1 7805 3870 747 mx2_x2
xsubckt_7737_mx3_x2 1 0 9128 7830 3896 1327 3797 3798 mx3_x2
xsubckt_7735_mx3_x2 1 0 9130 7830 3896 1330 3802 3804 mx3_x2
xsubckt_5877_ao22_x2 0 2750 1 2751 2756 7620 ao22_x2
xsubckt_4911_nand2_x0 1 0 3551 3554 1749 nand2_x0
xsubckt_3990_mx2_x2 0 3993 1 707 3994 3995 mx2_x2
xsubckt_3254_mx2_x2 0 4716 1 704 4717 4720 mx2_x2
xsubckt_3252_mx2_x2 0 4718 1 705 928 800 mx2_x2
xsubckt_3123_ao22_x2 0 4844 1 7216 4845 5586 ao22_x2
xsubckt_2982_oa22_x2 0 4983 1 4984 705 707 oa22_x2
xsubckt_591_a2_x2 0 7200 1 342 345 a2_x2
xsubckt_105_inv_x0 1 0 230 7686 inv_x0
xsubckt_103_inv_x0 1 0 1741 7688 inv_x0
xsubckt_101_inv_x0 1 0 600 7690 inv_x0
xsubckt_9887_sff1_x4 1 1872 0 8589 1623 sff1_x4
xsubckt_9364_sff1_x4 1 1872 0 9097 1040 sff1_x4
xsubckt_8913_sff1_x4 1 1872 0 9480 1846 sff1_x4
xsubckt_8218_a4_x2 0 7798 1 3901 3903 3906 3907 a4_x2
xsubckt_7953_mx2_x2 0 8896 1 7813 3878 909 mx2_x2
xsubckt_7951_mx2_x2 0 8898 1 7813 3886 913 mx2_x2
xsubckt_7465_nand2_x0 1 0 7995 7996 40 nand2_x0
xsubckt_7219_mx2_x2 0 8155 1 7199 7638 7639 mx2_x2
xsubckt_7217_mx2_x2 0 8156 1 7199 7640 7641 mx2_x2
xsubckt_7215_mx2_x2 0 9094 1 7199 408 376 mx2_x2
xsubckt_5260_nand3_x0 1 0 3254 40 129 7780 nand3_x0
xsubckt_3996_mx2_x2 0 3987 1 706 1074 978 mx2_x2
xsubckt_3994_mx2_x2 0 3989 1 706 1202 1138 mx2_x2
xsubckt_3355_oa22_x2 0 4617 1 990 705 707 oa22_x2
xsubckt_3258_mx2_x2 0 4712 1 705 1440 1280 mx2_x2
xsubckt_619_nand3_x0 1 0 7172 7180 40 7780 nand3_x0
xsubckt_109_inv_x0 1 0 45 7682 inv_x0
xsubckt_107_inv_x0 1 0 1739 7684 inv_x0
xsubckt_450_inv_x0 1 0 106 7341 inv_x0
xsubckt_452_inv_x0 1 0 105 7339 inv_x0
xsubckt_1516_nxr2_x1 6325 1 0 193 223 nxr2_x1
xsubckt_1846_ao22_x2 0 6007 1 6008 6016 6236 ao22_x2
xsubckt_2332_mx2_x2 0 5621 1 712 1550 1518 mx2_x2
xsubckt_9809_sff1_x4 1 1872 0 8667 1670 sff1_x4
xsubckt_9721_sff1_x4 1 1872 0 8755 766 sff1_x4
xsubckt_8987_sff1_x4 1 1872 0 9438 514 sff1_x4
xsubckt_8464_sff1_x4 1 1872 0 9929 722 sff1_x4
xsubckt_8257_nand2_x0 1 0 8581 7792 2856 nand2_x0
xsubckt_7329_a4_x2 0 8076 1 8079 8080 7670 7671 a4_x2
xsubckt_7058_ao22_x2 0 8242 1 8246 8245 8243 ao22_x2
xsubckt_6405_nand2_x0 1 0 2237 2238 712 nand2_x0
xsubckt_5479_nor3_x0 1 0 9501 3059 3060 7702 nor3_x0
xsubckt_5080_nand3_x0 1 0 3419 3534 3537 3540 nand3_x0
xsubckt_3018_a3_x2 1 4947 0 4948 5595 5608 a3_x2
xsubckt_2729_mx2_x2 0 5231 1 706 5232 5234 mx2_x2
xsubckt_2727_mx2_x2 0 5233 1 705 748 1612 mx2_x2
xsubckt_2725_mx2_x2 0 5235 1 705 1676 1548 mx2_x2
xsubckt_2681_mx2_x2 0 5278 1 705 1677 1549 mx2_x2
xsubckt_454_inv_x0 1 0 104 7337 inv_x0
xsubckt_456_inv_x0 1 0 103 7335 inv_x0
xsubckt_458_inv_x0 1 0 102 7333 inv_x0
xsubckt_1990_oa22_x2 0 1919 1 5881 5880 5876 oa22_x2
xsubckt_2219_ao22_x2 0 5732 1 5734 5740 711 ao22_x2
xsubckt_2334_mx2_x2 0 5619 1 710 5620 5621 mx2_x2
xsubckt_2336_mx2_x2 0 5617 1 712 750 718 mx2_x2
xsubckt_2338_mx2_x2 0 5615 1 711 5616 5619 mx2_x2
xsubckt_9795_sff1_x4 1 1872 0 8681 1683 sff1_x4
xsubckt_9272_sff1_x4 1 1872 0 9189 678 sff1_x4
xsubckt_8909_sff1_x4 1 1872 0 9484 1851 sff1_x4
xsubckt_8821_sff1_x4 1 1872 0 9572 65 sff1_x4
xsubckt_7389_a4_x2 0 8029 1 8030 8031 8035 8105 a4_x2
xsubckt_7179_mx2_x2 0 8159 1 8163 8160 525 mx2_x2
xsubckt_6515_ao22_x2 0 2129 1 534 532 692 ao22_x2
xsubckt_6493_nand2_x0 1 0 2151 2152 711 nand2_x0
xsubckt_6315_nand2_x0 1 0 2325 2326 7631 nand2_x0
xsubckt_6251_mx2_x2 0 2388 1 712 995 963 mx2_x2
xsubckt_5693_ao22_x2 0 2898 1 2899 2900 704 ao22_x2
xsubckt_5560_a3_x2 1 9479 0 3000 3001 40 a3_x2
xsubckt_5059_oa22_x2 0 9541 1 7168 3439 3445 oa22_x2
xsubckt_3786_oa22_x2 0 4193 1 4194 705 706 oa22_x2
xsubckt_3702_a3_x2 1 4275 0 4276 4277 4279 a3_x2
xsubckt_3238_nand2_x0 1 0 4731 4732 4739 nand2_x0
xsubckt_3078_a3_x2 1 4888 0 4889 4890 4892 a3_x2
xsubckt_2886_oa22_x2 0 5077 1 5088 5095 703 oa22_x2
xsubckt_2685_mx2_x2 0 5274 1 706 5275 5277 mx2_x2
xsubckt_2683_mx2_x2 0 5276 1 705 749 1613 mx2_x2
xsubckt_1034_a2_x2 0 6787 1 7143 1867 a2_x2
xsubckt_915_mx2_x2 0 6901 1 229 402 384 mx2_x2
xsubckt_833_o2_x2 0 6979 1 679 54 o2_x2
xsubckt_1654_nand2_x0 1 0 6187 7224 220 nand2_x0
xsubckt_1912_oa22_x2 0 5947 1 5948 6191 7788 oa22_x2
xsubckt_9717_sff1_x4 1 1872 0 8759 770 sff1_x4
xsubckt_8895_sff1_x4 1 1872 0 9498 1866 sff1_x4
xsubckt_8817_sff1_x4 1 1872 0 9576 1749 sff1_x4
xsubckt_8372_sff1_x4 1 1872 0 10013 1545 sff1_x4
xsubckt_6991_mx2_x2 0 8308 1 710 1138 978 mx2_x2
xsubckt_6589_ao22_x2 0 2057 1 7625 1595 2058 ao22_x2
xsubckt_6255_mx2_x2 0 2384 1 712 1219 1187 mx2_x2
xsubckt_6253_mx2_x2 0 2386 1 710 2387 2388 mx2_x2
xsubckt_5659_a3_x2 1 9452 0 2928 2929 40 a3_x2
xsubckt_5170_ao22_x2 0 3336 1 3337 3338 3342 ao22_x2
xsubckt_4905_a3_x2 1 9578 0 3556 3558 40 a3_x2
xsubckt_4896_nor4_x0 1 0 3562 3567 3631 7721 7722 nor4_x0
xsubckt_4016_nand4_x0 1 0 3967 5604 532 7689 55 nand4_x0
xsubckt_3755_nand3_x0 1 0 4223 4224 4409 5699 nand3_x0
xsubckt_3146_a2_x2 0 4822 1 4823 7218 a2_x2
xsubckt_2808_oa22_x2 0 5153 1 5595 5608 7280 oa22_x2
xsubckt_875_mx2_x2 0 6939 1 229 404 387 mx2_x2
xsubckt_1474_nand2_x0 1 0 6367 187 216 nand2_x0
xsubckt_9268_sff1_x4 1 1872 0 9193 521 sff1_x4
xsubckt_9180_sff1_x4 1 1872 0 9278 576 sff1_x4
xsubckt_8368_sff1_x4 1 1872 0 10017 1549 sff1_x4
xsubckt_6997_mx2_x2 0 8302 1 710 914 786 mx2_x2
xsubckt_6993_mx2_x2 0 8306 1 710 1426 1266 mx2_x2
xsubckt_5727_a2_x2 0 2864 1 2865 2866 a2_x2
xsubckt_5689_ao22_x2 0 2902 1 975 707 705 ao22_x2
xsubckt_4951_oa22_x2 0 9566 1 7168 3522 3524 oa22_x2
xsubckt_4028_nxr2_x1 3956 1 0 3958 3959 nxr2_x1
xsubckt_3090_nor2_x0 1 0 4877 4878 4881 nor2_x0
xsubckt_2698_a3_x2 1 5261 0 5262 5595 5608 a3_x2
xsubckt_1116_nand2_x0 1 0 6709 694 69 nand2_x0
xsubckt_1294_nand2_x0 1 0 6540 1818 589 nand2_x0
xsubckt_1368_a2_x2 0 6470 1 7143 1849 a2_x2
xsubckt_1563_a2_x2 0 6278 1 445 229 a2_x2
xsubckt_1620_xr2_x1 6221 0 1 195 225 xr2_x1
xsubckt_1908_oa22_x2 0 5951 1 6349 5969 5952 oa22_x2
xsubckt_9699_sff1_x4 1 1872 0 8777 787 sff1_x4
xsubckt_9625_sff1_x4 1 1872 0 8848 858 sff1_x4
xsubckt_9102_sff1_x4 1 1872 0 1926 1894 sff1_x4
xsubckt_8725_sff1_x4 1 1872 0 9668 1276 sff1_x4
xsubckt_7555_oa22_x2 0 7949 1 644 7679 678 oa22_x2
xsubckt_7044_o2_x2 0 8256 1 8257 7620 o2_x2
xsubckt_6999_mx2_x2 0 8300 1 712 8301 8302 mx2_x2
xsubckt_6497_ao22_x2 0 2147 1 2148 2149 708 ao22_x2
xsubckt_5680_mx2_x2 0 2911 1 7217 7371 7375 mx2_x2
xsubckt_5398_oa22_x2 0 3125 1 7690 3126 7680 oa22_x2
xsubckt_5243_nor2_x0 1 0 3269 3270 3271 nor2_x0
xsubckt_4947_oa22_x2 0 9567 1 7168 3525 3527 oa22_x2
xsubckt_4838_a2_x2 0 9594 1 3607 3608 a2_x2
xsubckt_4003_o2_x2 0 3980 1 3981 3983 o2_x2
xsubckt_3920_nxr2_x1 4062 1 0 209 681 nxr2_x1
xsubckt_2635_nor2_x0 1 0 5323 5325 7216 nor2_x0
xsubckt_1022_o2_x2 0 6799 1 698 73 o2_x2
xsubckt_21_inv_x0 1 0 126 7770 inv_x0
xsubckt_1816_oa22_x2 0 6034 1 6246 6046 6035 oa22_x2
xsubckt_2035_ao22_x2 0 5834 1 6413 5836 6111 ao22_x2
xsubckt_2086_nand2_x0 1 0 416 5791 5794 nand2_x0
xsubckt_9533_sff1_x4 1 1872 0 10105 1743 sff1_x4
xsubckt_9176_sff1_x4 1 1872 0 9282 584 sff1_x4
xsubckt_8799_sff1_x4 1 1872 0 9594 1769 sff1_x4
xsubckt_8110_mx3_x2 1 0 8747 7806 3896 757 3811 3813 mx3_x2
xsubckt_7603_nand4_x0 1 0 7912 7913 7951 7957 8140 nand4_x0
xsubckt_6825_nand2_x0 1 0 8470 8471 8472 nand2_x0
xsubckt_5684_mx2_x2 0 2907 1 7217 7363 7367 mx2_x2
xsubckt_5519_ao22_x2 0 3029 1 3034 1857 40 ao22_x2
xsubckt_5401_o2_x2 0 9515 1 3123 3133 o2_x2
xsubckt_5246_o2_x2 0 3266 1 3267 3276 o2_x2
xsubckt_5232_oa22_x2 0 3279 1 7087 3280 3282 oa22_x2
xsubckt_4937_mx3_x2 1 0 3532 5754 518 7754 7350 7351 mx3_x2
xsubckt_4933_mx3_x2 1 0 3535 5754 518 7753 7352 7353 mx3_x2
xsubckt_4898_a2_x2 0 9580 1 3561 3563 a2_x2
xsubckt_4546_mx3_x2 1 0 9724 3771 3897 1446 3859 3860 mx3_x2
xsubckt_4544_mx3_x2 1 0 9726 3771 3897 1418 3867 3868 mx3_x2
xsubckt_4153_mx3_x2 1 0 10040 3899 3896 1602 3847 3849 mx3_x2
xsubckt_4083_o2_x2 0 3902 1 517 526 o2_x2
xsubckt_3395_nand3_x0 1 0 4577 4578 4738 7104 nand3_x0
xsubckt_3086_nor2_x0 1 0 4881 4882 4883 nor2_x0
xsubckt_2956_nand2_x0 1 0 5008 7152 7273 nand2_x0
xsubckt_23_inv_x0 1 0 129 7768 inv_x0
xsubckt_25_inv_x0 1 0 131 7766 inv_x0
xsubckt_1328_nxr2_x1 6508 1 0 6509 6515 nxr2_x1
xsubckt_9010_sff1_x4 1 1872 0 9415 482 sff1_x4
xsubckt_8633_sff1_x4 1 1872 0 9760 1068 sff1_x4
xsubckt_8114_mx3_x2 1 0 8743 7806 3896 752 3799 3801 mx3_x2
xsubckt_8112_mx3_x2 1 0 8745 7806 3896 755 3805 3807 mx3_x2
xsubckt_7382_nor2_x0 1 0 8036 362 361 nor2_x0
xsubckt_6469_o2_x2 0 2174 1 2175 7134 o2_x2
xsubckt_5496_nand4_x0 1 0 3046 3055 1864 1865 1866 nand4_x0
xsubckt_4548_mx3_x2 1 0 9722 3771 3896 1444 3853 3855 mx3_x2
xsubckt_4157_mx3_x2 1 0 10039 3899 3896 1601 3844 3846 mx3_x2
xsubckt_702_a4_x2 0 7099 1 644 600 40 1742 a4_x2
xsubckt_683_nand2_x0 1 0 7114 7115 7117 nand2_x0
xsubckt_27_inv_x0 1 0 133 7764 inv_x0
xsubckt_29_inv_x0 1 0 135 7762 inv_x0
xsubckt_1356_o2_x2 0 6481 1 6482 6483 o2_x2
xsubckt_1367_oa22_x2 0 6471 1 387 7044 6880 oa22_x2
xsubckt_1984_nand2_x0 1 0 5881 5882 6398 nand2_x0
xsubckt_9529_sff1_x4 1 1872 0 8937 947 sff1_x4
xsubckt_9441_sff1_x4 1 1872 0 9025 1390 sff1_x4
xsubckt_9084_sff1_x4 1 1872 0 1936 1904 sff1_x4
xsubckt_9006_sff1_x4 1 1872 0 9419 494 sff1_x4
xsubckt_8074_mx3_x2 1 0 8781 7808 3896 791 3817 3819 mx3_x2
xsubckt_8072_mx3_x2 1 0 8783 7808 3896 793 3823 3825 mx3_x2
xsubckt_8070_mx3_x2 1 0 8785 7808 3896 795 3829 3831 mx3_x2
xsubckt_7347_nand2_x0 1 0 9283 8062 8064 nand2_x0
xsubckt_4371_mx2_x2 0 9888 1 3781 3874 972 mx2_x2
xsubckt_3917_o2_x2 0 4065 1 209 681 o2_x2
xsubckt_3568_nand2_x0 1 0 4407 7152 7261 nand2_x0
xsubckt_593_nand2_x0 1 0 7198 7200 7201 nand2_x0
xsubckt_2374_ao22_x2 0 5580 1 5581 5582 704 ao22_x2
xsubckt_8629_sff1_x4 1 1872 0 9764 1084 sff1_x4
xsubckt_8541_sff1_x4 1 1872 0 9852 1510 sff1_x4
xsubckt_8078_mx3_x2 1 0 8777 7808 3896 787 3805 3807 mx3_x2
xsubckt_8076_mx3_x2 1 0 8779 7808 3896 789 3811 3813 mx3_x2
xsubckt_8049_nand2_x0 1 0 7807 3787 3793 nand2_x0
xsubckt_7932_mx3_x2 1 0 8915 7816 3896 1214 3835 3837 mx3_x2
xsubckt_7930_mx3_x2 1 0 8917 7816 3896 1216 3841 3843 mx3_x2
xsubckt_7658_ao22_x2 0 9169 1 7870 7867 7868 ao22_x2
xsubckt_7570_ao22_x2 0 9186 1 7956 7938 7940 ao22_x2
xsubckt_6471_oa22_x2 0 2173 1 40 1741 190 oa22_x2
xsubckt_5556_nor3_x0 1 0 9480 3003 3004 7702 nor3_x0
xsubckt_3842_mx2_x2 0 4138 1 705 757 1621 mx2_x2
xsubckt_3106_mx2_x2 0 4861 1 705 1411 1251 mx2_x2
xsubckt_3104_mx2_x2 0 4863 1 7217 7501 7503 mx2_x2
xsubckt_2532_oa22_x2 0 5424 1 5425 5450 5585 oa22_x2
xsubckt_1039_ao22_x2 0 6782 1 6783 6787 7038 ao22_x2
xsubckt_842_nand3_x0 1 0 6970 6971 6972 6973 nand3_x0
xsubckt_642_nor4_x0 1 0 7153 577 575 576 578 nor4_x0
xsubckt_635_a3_x2 1 447 0 7160 7202 40 a3_x2
xsubckt_9872_sff1_x4 1 1872 0 8604 1609 sff1_x4
xsubckt_9437_sff1_x4 1 1872 0 9029 1416 sff1_x4
xsubckt_7938_mx3_x2 1 0 8909 7816 3896 1207 3817 3819 mx3_x2
xsubckt_7936_mx3_x2 1 0 8911 7816 3896 1209 3823 3825 mx3_x2
xsubckt_7934_mx3_x2 1 0 8913 7816 3896 1211 3829 3831 mx3_x2
xsubckt_7414_mx2_x2 0 9262 1 5752 9083 669 mx2_x2
xsubckt_7412_mx2_x2 0 9065 1 7199 385 353 mx2_x2
xsubckt_7410_mx2_x2 0 9066 1 7199 387 355 mx2_x2
xsubckt_7154_mx3_x2 1 0 9362 8167 3896 1314 3847 3849 mx3_x2
xsubckt_7152_mx3_x2 1 0 9364 8167 3896 1316 3853 3855 mx3_x2
xsubckt_7150_mx3_x2 1 0 9366 8167 3897 1318 3859 3860 mx3_x2
xsubckt_6916_oa22_x2 0 8381 1 7401 7625 7631 oa22_x2
xsubckt_6892_nand3_x0 1 0 8404 8405 8419 7620 nand3_x0
xsubckt_5136_oa22_x2 0 3368 1 7680 3520 7167 oa22_x2
xsubckt_4433_nand2_x0 1 0 3776 3796 3904 nand2_x0
xsubckt_3848_mx2_x2 0 4132 1 705 1205 1077 mx2_x2
xsubckt_3846_mx2_x2 0 4134 1 7219 4135 4136 mx2_x2
xsubckt_3844_mx2_x2 0 4136 1 705 1717 885 mx2_x2
xsubckt_3457_mx2_x2 0 4517 1 7217 7458 7460 mx2_x2
xsubckt_3340_oa22_x2 0 4632 1 4676 4678 4679 oa22_x2
xsubckt_3062_mx2_x2 0 4904 1 705 1508 1348 mx2_x2
xsubckt_3060_mx2_x2 0 4906 1 706 4907 4910 mx2_x2
xsubckt_723_a2_x2 0 7080 1 7081 7135 a2_x2
xsubckt_675_a3_x2 1 7121 0 7122 7124 7130 a3_x2
xsubckt_300_inv_x0 1 0 862 7491 inv_x0
xsubckt_302_inv_x0 1 0 798 7489 inv_x0
xsubckt_304_inv_x0 1 0 1662 7487 inv_x0
xsubckt_2005_oa22_x2 0 5862 1 6396 5885 6162 oa22_x2
xsubckt_8972_sff1_x4 1 1872 0 153 90 sff1_x4
xsubckt_8537_sff1_x4 1 1872 0 9856 1484 sff1_x4
xsubckt_7894_mx3_x2 1 0 8951 7818 3896 962 3847 3849 mx3_x2
xsubckt_7892_mx3_x2 1 0 8953 7818 3896 964 3853 3855 mx3_x2
xsubckt_7890_mx3_x2 1 0 8955 7818 3897 966 3859 3860 mx3_x2
xsubckt_7566_ao22_x2 0 9187 1 7956 7941 7943 ao22_x2
xsubckt_7418_mx2_x2 0 9064 1 7199 384 352 mx2_x2
xsubckt_7158_mx3_x2 1 0 9358 8167 3896 1310 3835 3837 mx3_x2
xsubckt_7156_mx3_x2 1 0 9360 8167 3896 1312 3841 3843 mx3_x2
xsubckt_7077_nand2_x0 1 0 8224 8225 8226 nand2_x0
xsubckt_6195_nand2_x0 1 0 2442 2443 7628 nand2_x0
xsubckt_3461_nand2_x0 1 0 4513 4514 4516 nand2_x0
xsubckt_3459_mx2_x2 0 4515 1 705 1467 1307 mx2_x2
xsubckt_3016_nand4_x0 1 0 4949 5604 532 7689 74 nand4_x0
xsubckt_2922_mx2_x2 0 5042 1 705 1414 1254 mx2_x2
xsubckt_260_inv_x0 1 0 1033 7531 inv_x0
xsubckt_306_inv_x0 1 0 1406 7485 inv_x0
xsubckt_308_inv_x0 1 0 1246 7483 inv_x0
xsubckt_1382_ao22_x2 0 6457 1 6478 6475 6476 ao22_x2
xsubckt_9868_sff1_x4 1 1872 0 8608 1613 sff1_x4
xsubckt_9780_sff1_x4 1 1872 0 8696 1699 sff1_x4
xsubckt_9345_sff1_x4 1 1872 0 9116 1061 sff1_x4
xsubckt_8968_sff1_x4 1 1872 0 157 94 sff1_x4
xsubckt_8445_sff1_x4 1 1872 0 9948 742 sff1_x4
xsubckt_7947_nand2_x0 1 0 7813 3787 3904 nand2_x0
xsubckt_7898_mx3_x2 1 0 8947 7818 3896 958 3835 3837 mx3_x2
xsubckt_7896_mx3_x2 1 0 8949 7818 3896 960 3841 3843 mx3_x2
xsubckt_7400_ao22_x2 0 8021 1 645 7680 587 ao22_x2
xsubckt_7267_a4_x2 0 8119 1 8120 2853 7679 644 a4_x2
xsubckt_7247_a4_x2 0 8134 1 8136 2853 7679 644 a4_x2
xsubckt_7120_nor2_x0 1 0 8182 1742 1740 nor2_x0
xsubckt_6534_nand3_x0 1 0 2111 2114 2117 711 nand3_x0
xsubckt_6101_mx2_x2 0 2534 1 710 745 1609 mx2_x2
xsubckt_5028_a3_x2 1 3464 0 40 56 7780 a3_x2
xsubckt_5008_a3_x2 1 3479 0 40 61 7780 a3_x2
xsubckt_4715_a4_x2 0 3701 1 3718 3745 1801 1800 a4_x2
xsubckt_4119_a3_x2 1 3873 0 3881 49 48 a3_x2
xsubckt_4105_nxr2_x1 3884 1 0 3889 7724 nxr2_x1
xsubckt_3970_ao22_x2 0 4012 1 7180 4059 4013 ao22_x2
xsubckt_2928_mx2_x2 0 5036 1 705 1478 1318 mx2_x2
xsubckt_2924_mx2_x2 0 5040 1 705 1446 1286 mx2_x2
xsubckt_262_inv_x0 1 0 1381 7529 inv_x0
xsubckt_264_inv_x0 1 0 869 7527 inv_x0
xsubckt_266_inv_x0 1 0 773 7525 inv_x0
xsubckt_2027_a3_x2 1 5841 0 5842 5843 5844 a3_x2
xsubckt_2058_nand2_x0 1 0 5813 6112 6424 nand2_x0
xsubckt_9776_sff1_x4 1 1872 0 8700 1673 sff1_x4
xsubckt_9702_sff1_x4 1 1872 0 8774 783 sff1_x4
xsubckt_8880_sff1_x4 1 1872 0 9513 116 sff1_x4
xsubckt_8802_sff1_x4 1 1872 0 9591 1766 sff1_x4
xsubckt_6450_mx2_x2 0 2193 1 710 1727 895 mx2_x2
xsubckt_6236_mx3_x2 1 0 2402 712 710 2403 868 1380 mx3_x2
xsubckt_6220_a2_x2 0 2418 1 7515 710 a2_x2
xsubckt_5116_a2_x2 0 3386 1 3525 661 a2_x2
xsubckt_4735_a4_x2 0 3685 1 3688 3696 3707 3711 a4_x2
xsubckt_4159_nand3_x0 1 0 3842 3848 70 69 nand3_x0
xsubckt_3445_a3_x2 1 4528 0 4529 4531 4532 a3_x2
xsubckt_3281_nand2_x0 1 0 4689 7153 7272 nand2_x0
xsubckt_3103_nand2_x0 1 0 4864 4865 4867 nand2_x0
xsubckt_3008_ao22_x2 0 4957 1 7218 4958 703 ao22_x2
xsubckt_1098_nor2_x0 1 0 6726 6728 6729 nor2_x0
xsubckt_268_inv_x0 1 0 1637 7523 inv_x0
xsubckt_1212_ao22_x2 0 6618 1 6643 6636 6622 ao22_x2
xsubckt_1971_oa22_x2 0 5893 1 5909 6175 6372 oa22_x2
xsubckt_2355_nor2_x0 1 0 5599 583 584 nor2_x0
xsubckt_9610_sff1_x4 1 1872 0 8863 844 sff1_x4
xsubckt_9253_sff1_x4 1 1872 0 9208 325 sff1_x4
xsubckt_8876_sff1_x4 1 1872 0 9517 121 sff1_x4
xsubckt_8353_sff1_x4 1 1872 0 10032 1593 sff1_x4
xsubckt_6795_nand2_x0 1 0 8499 8500 8505 nand2_x0
xsubckt_6707_nand2_x0 1 0 1942 1943 7631 nand2_x0
xsubckt_6456_mx2_x2 0 2187 1 710 1183 1055 mx2_x2
xsubckt_6454_mx2_x2 0 2189 1 710 1215 1087 mx2_x2
xsubckt_6452_mx2_x2 0 2191 1 709 2192 2195 mx2_x2
xsubckt_6194_mx3_x2 1 0 2443 712 710 2444 7517 7519 mx3_x2
xsubckt_6174_nand3_x0 1 0 2463 2477 2479 711 nand3_x0
xsubckt_6061_mx2_x2 0 2573 1 708 2574 2576 mx2_x2
xsubckt_5557_a3_x2 1 3002 0 3007 1846 1845 a3_x2
xsubckt_5239_ao22_x2 0 3273 1 600 3274 644 ao22_x2
xsubckt_4803_a3_x2 1 3634 0 1781 1780 1778 a3_x2
xsubckt_2751_a3_x2 1 5209 0 5210 5211 5213 a3_x2
xsubckt_2556_a3_x2 1 5401 0 5402 5406 703 a3_x2
xsubckt_2499_mx2_x2 0 5457 1 707 5458 5459 mx2_x2
xsubckt_2497_mx2_x2 0 5459 1 705 1372 860 mx2_x2
xsubckt_1009_oa22_x2 0 6811 1 406 7042 6812 oa22_x2
xsubckt_1441_a2_x2 0 6400 1 184 213 a2_x2
xsubckt_1956_nand2_x0 1 0 5907 6362 6367 nand2_x0
xsubckt_2131_nand2_x0 1 0 429 5762 5792 nand2_x0
xsubckt_9684_sff1_x4 1 1872 0 8792 803 sff1_x4
xsubckt_9249_sff1_x4 1 1872 0 9212 330 sff1_x4
xsubckt_8710_sff1_x4 1 1872 0 9683 1117 sff1_x4
xsubckt_6808_a2_x2 0 8487 1 8488 7613 a2_x2
xsubckt_6458_mx2_x2 0 2185 1 710 1471 1311 mx2_x2
xsubckt_6084_nand3_x0 1 0 2551 2554 2557 711 nand3_x0
xsubckt_6047_ao22_x2 0 2587 1 2592 2590 2588 ao22_x2
xsubckt_5923_mx2_x2 0 2708 1 710 1709 877 mx2_x2
xsubckt_5921_mx2_x2 0 2710 1 7631 2711 2712 mx2_x2
xsubckt_5840_a2_x2 0 2786 1 7082 7135 a2_x2
xsubckt_5735_nand2_x0 1 0 2857 7697 40 nand2_x0
xsubckt_5721_nand4_x0 1 0 2870 2871 2872 5588 5604 nand4_x0
xsubckt_5709_mx3_x2 1 0 2882 707 705 2883 1039 1167 mx3_x2
xsubckt_5383_oa22_x2 0 3139 1 3141 3143 7690 oa22_x2
xsubckt_5344_nxr2_x1 3176 1 0 3185 3471 nxr2_x1
xsubckt_2748_nand2_x0 1 0 5212 7152 7277 nand2_x0
xsubckt_2701_oa22_x2 0 5259 1 5309 5307 5308 oa22_x2
xsubckt_1120_ao22_x2 0 6705 1 6733 6728 6708 ao22_x2
xsubckt_1266_a2_x2 0 6567 1 685 60 a2_x2
xsubckt_1461_a2_x2 0 6380 1 185 214 a2_x2
xsubckt_1735_a2_x2 0 6106 1 6107 6108 a2_x2
xsubckt_1801_oa22_x2 0 6047 1 6298 6048 6049 oa22_x2
xsubckt_1866_nand2_x0 1 0 1931 5989 5993 nand2_x0
xsubckt_1910_a2_x2 0 5949 1 6198 6347 a2_x2
xsubckt_9606_sff1_x4 1 1872 0 8867 860 sff1_x4
xsubckt_9161_sff1_x4 1 1872 0 9297 597 sff1_x4
xsubckt_8784_sff1_x4 1 1872 0 9609 1786 sff1_x4
xsubckt_8349_sff1_x4 1 1872 0 10036 1598 sff1_x4
xsubckt_7378_ao22_x2 0 8040 1 645 7680 590 ao22_x2
xsubckt_7319_nand2_x0 1 0 8084 8138 608 nand2_x0
xsubckt_7290_ao22_x2 0 8104 1 645 7680 597 ao22_x2
xsubckt_6828_a2_x2 0 8467 1 8468 708 a2_x2
xsubckt_5929_mx2_x2 0 2702 1 710 1485 1325 mx2_x2
xsubckt_5927_mx2_x2 0 2704 1 712 2705 2706 mx2_x2
xsubckt_5925_mx2_x2 0 2706 1 710 1165 1037 mx2_x2
xsubckt_5252_nxr2_x1 3261 1 0 3493 650 nxr2_x1
xsubckt_4796_a2_x2 0 9604 1 3639 3640 a2_x2
xsubckt_3951_nor2_x0 1 0 4031 4032 704 nor2_x0
xsubckt_3032_o2_x2 0 4934 1 705 1668 o2_x2
xsubckt_1795_a2_x2 0 6053 1 6054 6055 a2_x2
xsubckt_9592_sff1_x4 1 1872 0 8881 923 sff1_x4
xsubckt_9157_sff1_x4 1 1872 0 9301 599 sff1_x4
xsubckt_8706_sff1_x4 1 1872 0 9687 1121 sff1_x4
xsubckt_7660_nand2_x0 1 0 7865 659 600 nand2_x0
xsubckt_7139_nand2_x0 1 0 8166 3766 3900 nand2_x0
xsubckt_6307_o2_x2 0 2333 1 1666 710 o2_x2
xsubckt_5979_a2_x2 0 9406 1 2654 2694 a2_x2
xsubckt_5379_oa22_x2 0 3143 1 3162 3157 3144 oa22_x2
xsubckt_4612_mx2_x2 0 9664 1 3764 3874 1260 mx2_x2
xsubckt_4610_mx2_x2 0 9666 1 3764 3882 1262 mx2_x2
xsubckt_4354_mx3_x2 1 0 9901 3786 3896 1526 3814 3816 mx3_x2
xsubckt_4352_mx3_x2 1 0 9903 3786 3896 1528 3820 3822 mx3_x2
xsubckt_4350_mx3_x2 1 0 9905 3786 3896 1530 3826 3828 mx3_x2
xsubckt_2998_a2_x2 0 4967 1 4968 7217 a2_x2
xsubckt_1019_o2_x2 0 6801 1 6802 6808 o2_x2
xsubckt_1309_nxr2_x1 6526 1 0 6528 6529 nxr2_x1
xsubckt_1438_xr2_x1 6403 0 1 183 212 xr2_x1
xsubckt_9514_sff1_x4 1 1872 0 8952 963 sff1_x4
xsubckt_8692_sff1_x4 1 1872 0 9701 1127 sff1_x4
xsubckt_7444_oa22_x2 0 8007 1 8008 8073 8096 oa22_x2
xsubckt_5935_ao22_x2 0 2696 1 534 532 675 ao22_x2
xsubckt_4358_mx3_x2 1 0 9897 3786 3896 1522 3802 3804 mx3_x2
xsubckt_4356_mx3_x2 1 0 9899 3786 3896 1524 3808 3810 mx3_x2
xsubckt_4227_mx2_x2 0 10019 1 3794 3886 1553 mx2_x2
xsubckt_4225_mx2_x2 0 10021 1 3794 3892 1575 mx2_x2
xsubckt_3947_nor2_x0 1 0 4035 4036 7216 nor2_x0
xsubckt_2652_o2_x2 0 5307 1 203 675 o2_x2
xsubckt_778_ao22_x2 0 7031 1 7032 7036 7038 ao22_x2
xsubckt_1348_oa22_x2 0 6489 1 388 7044 6880 oa22_x2
xsubckt_1396_xr2_x1 6444 0 1 677 52 xr2_x1
xsubckt_1703_o2_x2 0 6138 1 446 230 o2_x2
xsubckt_9588_sff1_x4 1 1872 0 8885 928 sff1_x4
xsubckt_9065_sff1_x4 1 1872 0 9361 1313 sff1_x4
xsubckt_8688_sff1_x4 1 1872 0 9705 1426 sff1_x4
xsubckt_8614_sff1_x4 1 1872 0 9779 1469 sff1_x4
xsubckt_5624_nand3_x0 1 0 2953 2959 1825 1827 nand3_x0
xsubckt_5486_ao22_x2 0 3053 1 3058 1867 40 ao22_x2
xsubckt_4918_nand4_x0 1 0 3546 3554 1749 1748 1747 nand4_x0
xsubckt_4742_nand3_x0 1 0 3680 3685 1794 1793 nand3_x0
xsubckt_4574_mx2_x2 0 9699 1 3767 3886 1105 mx2_x2
xsubckt_4572_mx2_x2 0 9701 1 3767 3892 1127 mx2_x2
xsubckt_4229_mx2_x2 0 10017 1 3794 3878 1549 mx2_x2
xsubckt_3690_ao22_x2 0 4287 1 1400 705 707 ao22_x2
xsubckt_3301_mx2_x2 0 4670 1 705 1119 959 mx2_x2
xsubckt_2551_nand2_x0 1 0 5406 5407 704 nand2_x0
xsubckt_2461_nand2_x0 1 0 5494 5495 5496 nand2_x0
xsubckt_1238_nand2_x0 1 0 6593 587 1757 nand2_x0
xsubckt_1982_ao22_x2 0 5883 1 5884 5891 6378 ao22_x2
xsubckt_9422_sff1_x4 1 1872 0 9044 1373 sff1_x4
xsubckt_8522_sff1_x4 1 1872 0 9871 984 sff1_x4
xsubckt_7551_ao22_x2 0 7952 1 536 531 352 ao22_x2
xsubckt_7245_nor3_x0 1 0 8136 373 372 371 nor3_x0
xsubckt_7122_nand2_x0 1 0 8180 8182 2829 nand2_x0
xsubckt_7002_mx3_x2 1 0 8297 712 710 8298 1522 1650 mx3_x2
xsubckt_5156_nxr2_x1 3349 1 0 3367 3517 nxr2_x1
xsubckt_4576_mx2_x2 0 9697 1 3767 3878 1101 mx2_x2
xsubckt_3860_nand3_x0 1 0 4120 4121 4278 5699 nand3_x0
xsubckt_3390_mx3_x2 1 0 4582 707 705 4583 862 1374 mx3_x2
xsubckt_3307_mx2_x2 0 4664 1 705 1439 1279 mx2_x2
xsubckt_3303_mx2_x2 0 4668 1 707 4669 4670 mx2_x2
xsubckt_1058_nand2_x0 1 0 6764 1831 589 nand2_x0
xsubckt_807_nand2_x0 1 0 7004 7005 1737 nand2_x0
xsubckt_601_a2_x2 0 7190 1 1737 40 a2_x2
xsubckt_1401_nand2_x0 1 0 6439 587 1747 nand2_x0
xsubckt_1665_nand3_x0 1 0 6176 6365 7226 217 nand3_x0
xsubckt_2371_nand2_x0 1 0 5583 5584 7219 nand2_x0
xsubckt_9853_sff1_x4 1 1872 0 8623 1241 sff1_x4
xsubckt_9496_sff1_x4 1 1872 0 8970 1172 sff1_x4
xsubckt_9418_sff1_x4 1 1872 0 9048 1377 sff1_x4
xsubckt_8596_sff1_x4 1 1872 0 9797 1479 sff1_x4
xsubckt_7739_nand2_x0 1 0 7827 3783 3900 nand2_x0
xsubckt_7649_nand2_x0 1 0 7874 649 600 nand2_x0
xsubckt_6216_ao22_x2 0 2422 1 7628 2427 708 ao22_x2
xsubckt_4738_nand4_x0 1 0 3683 3688 3701 1799 1794 nand4_x0
xsubckt_3652_mx2_x2 0 4325 1 705 1688 1560 mx2_x2
xsubckt_3392_mx3_x2 1 0 4580 706 7215 4581 4587 4595 mx3_x2
xsubckt_3309_mx2_x2 0 4662 1 705 1023 831 mx2_x2
xsubckt_3163_ao22_x2 0 4805 1 802 7217 707 ao22_x2
xsubckt_3073_nand2_x0 1 0 4893 7152 7271 nand2_x0
xsubckt_2587_oa22_x2 0 5370 1 5422 5421 5420 oa22_x2
xsubckt_895_nand2_x0 1 0 6920 6921 7047 nand2_x0
xsubckt_703_nand4_x0 1 0 7098 644 600 40 1742 nand4_x0
xsubckt_627_nand2_x0 1 0 7164 7165 7166 nand2_x0
xsubckt_112_inv_x0 1 0 645 7679 inv_x0
xsubckt_110_inv_x0 1 0 43 7681 inv_x0
xsubckt_501_inv_x0 1 0 204 7290 inv_x0
xsubckt_503_inv_x0 1 0 203 7288 inv_x0
xsubckt_1560_nxr2_x1 6281 1 0 434 218 nxr2_x1
xsubckt_2064_oa22_x2 0 5808 1 5809 6150 6426 oa22_x2
xsubckt_2103_nand2_x0 1 0 5777 196 307 nand2_x0
xsubckt_2263_ao22_x2 0 5689 1 7631 5690 7620 ao22_x2
xsubckt_9330_sff1_x4 1 1872 0 9131 1331 sff1_x4
xsubckt_8953_sff1_x4 1 1872 0 143 80 sff1_x4
xsubckt_8518_sff1_x4 1 1872 0 9875 989 sff1_x4
xsubckt_8430_sff1_x4 1 1872 0 9963 884 sff1_x4
xsubckt_7748_mx3_x2 1 0 9119 7828 3897 1034 3867 3868 mx3_x2
xsubckt_7226_mx2_x2 0 8151 1 7199 7634 7635 mx2_x2
xsubckt_7224_mx2_x2 0 8152 1 7199 7636 7637 mx2_x2
xsubckt_7222_mx2_x2 0 8153 1 7199 7632 7633 mx2_x2
xsubckt_7024_ao22_x2 0 9383 1 8276 8278 8309 ao22_x2
xsubckt_6677_nand2_x0 1 0 1971 1972 711 nand2_x0
xsubckt_5064_nxr2_x1 3434 1 0 3538 646 nxr2_x1
xsubckt_4164_nxr2_x1 3838 1 0 3842 68 nxr2_x1
xsubckt_4124_a4_x2 0 3869 1 3881 49 48 47 a4_x2
xsubckt_3520_ao22_x2 0 4455 1 7443 7217 706 ao22_x2
xsubckt_3265_mx2_x2 0 4705 1 705 1376 864 mx2_x2
xsubckt_935_a2_x2 0 6882 1 6899 525 a2_x2
xsubckt_116_inv_x0 1 0 529 7675 inv_x0
xsubckt_114_inv_x0 1 0 530 7677 inv_x0
xsubckt_505_inv_x0 1 0 394 7286 inv_x0
xsubckt_507_inv_x0 1 0 1810 7284 inv_x0
xsubckt_509_inv_x0 1 0 393 7282 inv_x0
xsubckt_1928_nand2_x0 1 0 5932 6114 6346 nand2_x0
xsubckt_2013_nand2_x0 1 0 5854 6112 6389 nand2_x0
xsubckt_9849_sff1_x4 1 1872 0 8627 1246 sff1_x4
xsubckt_9761_sff1_x4 1 1872 0 8715 1717 sff1_x4
xsubckt_9326_sff1_x4 1 1872 0 9135 1335 sff1_x4
xsubckt_7380_a4_x2 0 8038 1 7666 7667 7679 644 a4_x2
xsubckt_7184_mx2_x2 0 9341 1 8157 3892 1159 mx2_x2
xsubckt_6930_nand2_x0 1 0 8367 8392 7613 nand2_x0
xsubckt_6587_nand2_x0 1 0 2059 2060 711 nand2_x0
xsubckt_6409_nand2_x0 1 0 2233 2234 7628 nand2_x0
xsubckt_6300_mx2_x2 0 2340 1 710 2341 2342 mx2_x2
xsubckt_5548_oa22_x2 0 3008 1 1850 3015 1849 oa22_x2
xsubckt_5460_oa22_x2 0 3072 1 1837 3079 1826 oa22_x2
xsubckt_5093_a4_x2 0 3407 1 3531 3534 3537 3540 a4_x2
xsubckt_4851_ao22_x2 0 3597 1 3600 7716 7717 ao22_x2
xsubckt_4017_a3_x2 1 3966 0 3967 3968 3970 a3_x2
xsubckt_3232_nand3_x0 1 0 4737 4738 4891 5699 nand3_x0
xsubckt_3084_xr2_x1 4883 0 1 225 697 xr2_x1
xsubckt_2867_mx3_x2 1 0 5096 707 705 5097 841 1353 mx3_x2
xsubckt_2736_mx2_x2 0 5224 1 706 1164 1100 mx2_x2
xsubckt_700_nand2_x0 1 0 7101 644 600 nand2_x0
xsubckt_118_inv_x0 1 0 531 7673 inv_x0
xsubckt_461_inv_x0 1 0 1897 7330 inv_x0
xsubckt_463_inv_x0 1 0 1896 7328 inv_x0
xsubckt_465_inv_x0 1 0 1895 7326 inv_x0
xsubckt_2009_nand3_x0 1 0 5858 5860 5861 6385 nand3_x0
xsubckt_8949_sff1_x4 1 1872 0 159 96 sff1_x4
xsubckt_8861_sff1_x4 1 1872 0 9532 137 sff1_x4
xsubckt_8426_sff1_x4 1 1872 0 9967 888 sff1_x4
xsubckt_7233_a3_x2 1 8146 0 8151 9091 8153 a3_x2
xsubckt_7188_mx2_x2 0 9337 1 8157 3878 1133 mx2_x2
xsubckt_7186_mx2_x2 0 9339 1 8157 3886 1137 mx2_x2
xsubckt_6879_oa22_x2 0 8417 1 7408 7625 7631 oa22_x2
xsubckt_6304_mx2_x2 0 2336 1 710 1698 1570 mx2_x2
xsubckt_4907_a4_x2 0 3554 1 3562 1753 1752 1750 a4_x2
xsubckt_3748_oa22_x2 0 4230 1 4241 4248 703 oa22_x2
xsubckt_3067_ao22_x2 0 4899 1 1412 705 707 ao22_x2
xsubckt_2852_oa22_x2 0 5110 1 5133 5117 5111 oa22_x2
xsubckt_2738_mx2_x2 0 5222 1 706 1036 940 mx2_x2
xsubckt_748_oa22_x2 0 10096 1 307 7169 7058 oa22_x2
xsubckt_467_inv_x0 1 0 1894 7324 inv_x0
xsubckt_469_inv_x0 1 0 1893 7322 inv_x0
xsubckt_1231_a3_x2 1 6600 0 6619 6620 6623 a3_x2
xsubckt_1359_ao22_x2 0 6479 1 6497 6492 6494 ao22_x2
xsubckt_1794_ao22_x2 0 6054 1 418 7285 574 ao22_x2
xsubckt_1911_nand2_x0 1 0 5948 6198 6347 nand2_x0
xsubckt_9757_sff1_x4 1 1872 0 8719 1721 sff1_x4
xsubckt_9234_sff1_x4 1 1872 0 9227 315 sff1_x4
xsubckt_7341_a2_x2 0 8066 1 8067 8136 a2_x2
xsubckt_6788_mx3_x2 1 0 8506 712 710 8507 7412 7414 mx3_x2
xsubckt_6746_nand3_x0 1 0 8547 8549 8551 7620 nand3_x0
xsubckt_6260_mx2_x2 0 2379 1 710 1699 1571 mx2_x2
xsubckt_5670_a3_x2 1 9449 0 2920 2921 40 a3_x2
xsubckt_5347_nand2_x0 1 0 3173 3189 3200 nand2_x0
xsubckt_5132_ao22_x2 0 3371 1 7086 3372 3374 ao22_x2
xsubckt_5054_a2_x2 0 3443 1 3540 647 a2_x2
xsubckt_4741_a3_x2 1 3681 0 3685 1794 1793 a3_x2
xsubckt_4721_a3_x2 1 3696 0 1801 1800 1799 a3_x2
xsubckt_1124_a2_x2 0 6701 1 7143 1863 a2_x2
xsubckt_1068_oa22_x2 0 6755 1 6798 6776 6778 oa22_x2
xsubckt_1821_nand2_x0 1 0 6029 6114 6307 nand2_x0
xsubckt_2073_a2_x2 0 5800 1 230 7687 a2_x2
xsubckt_8857_sff1_x4 1 1872 0 9536 111 sff1_x4
xsubckt_8334_sff1_x4 1 1872 0 10051 1585 sff1_x4
xsubckt_7810_a2_x2 0 7822 1 3780 3787 a2_x2
xsubckt_7448_nand3_x0 1 0 8004 7679 644 7691 nand3_x0
xsubckt_6986_ao22_x2 0 8312 1 534 532 681 ao22_x2
xsubckt_6921_a2_x2 0 8376 1 7400 710 a2_x2
xsubckt_6656_nand3_x0 1 0 1991 1992 2016 2729 nand3_x0
xsubckt_5543_a2_x2 0 3012 1 3015 1850 a2_x2
xsubckt_5368_a2_x2 0 3153 1 3177 3468 a2_x2
xsubckt_4991_oa22_x2 0 9556 1 7168 3492 3494 oa22_x2
xsubckt_4913_oa22_x2 0 3550 1 3554 1749 1748 oa22_x2
xsubckt_4858_nor4_x0 1 0 3591 3594 3605 3631 7718 nor4_x0
xsubckt_3491_a2_x2 0 4483 1 4484 5586 a2_x2
xsubckt_3296_a2_x2 0 4675 1 4676 4678 a2_x2
xsubckt_1110_nand3_x0 1 0 6714 6715 6716 6717 nand3_x0
xsubckt_1184_a2_x2 0 6644 1 6645 6653 a2_x2
xsubckt_1388_nand2_x0 1 0 6451 587 1748 nand2_x0
xsubckt_1418_a2_x2 0 6423 1 178 206 a2_x2
xsubckt_1613_a2_x2 0 6228 1 6229 6231 a2_x2
xsubckt_1633_a2_x2 0 6208 1 194 224 a2_x2
xsubckt_1817_nand3_x0 1 0 6033 6034 6036 6305 nand3_x0
xsubckt_1860_oa22_x2 0 5994 1 5996 5998 6221 oa22_x2
xsubckt_9665_sff1_x4 1 1872 0 8811 821 sff1_x4
xsubckt_9142_sff1_x4 1 1872 0 9316 1141 sff1_x4
xsubckt_8765_sff1_x4 1 1872 0 9628 1744 sff1_x4
xsubckt_7595_oa22_x2 0 7919 1 644 7679 689 oa22_x2
xsubckt_7182_nand2_x0 1 0 8157 3769 3796 nand2_x0
xsubckt_6621_oa22_x2 0 2026 1 2027 710 711 oa22_x2
xsubckt_6566_nand3_x0 1 0 2079 2080 2105 2729 nand3_x0
xsubckt_5737_mx2_x2 0 9446 1 2856 467 504 mx2_x2
xsubckt_5563_ao22_x2 0 2997 1 3002 1844 40 ao22_x2
xsubckt_4987_oa22_x2 0 9557 1 7168 3495 3497 oa22_x2
xsubckt_1101_ao22_x2 0 6723 1 7281 7041 6724 ao22_x2
xsubckt_957_nand2_x0 1 0 6861 6862 6888 nand2_x0
xsubckt_1478_a2_x2 0 6363 1 188 217 a2_x2
xsubckt_1551_nand2_x0 1 0 6290 7247 203 nand2_x0
xsubckt_1635_xr2_x1 6206 0 1 194 224 xr2_x1
xsubckt_1693_a2_x2 0 6148 1 6149 6430 a2_x2
xsubckt_2021_o2_x2 0 5847 1 5848 6390 o2_x2
xsubckt_9138_sff1_x4 1 1872 0 9320 1145 sff1_x4
xsubckt_6894_ao22_x2 0 8402 1 534 532 683 ao22_x2
xsubckt_6829_nand2_x0 1 0 8466 8467 8470 nand2_x0
xsubckt_6617_oa22_x2 0 2030 1 2031 710 7628 oa22_x2
xsubckt_6440_o2_x2 0 2203 1 2204 709 o2_x2
xsubckt_5947_nand2_x0 1 0 2685 2686 2687 nand2_x0
xsubckt_5739_mx2_x2 0 9444 1 2856 453 490 mx2_x2
xsubckt_4553_mx3_x2 1 0 9717 3771 3896 1439 3838 3840 mx3_x2
xsubckt_4551_mx3_x2 1 0 9719 3771 3896 1441 3844 3846 mx3_x2
xsubckt_3328_ao22_x2 0 4643 1 706 4644 5586 ao22_x2
xsubckt_956_nxr2_x1 6862 1 0 671 46 nxr2_x1
xsubckt_30_inv_x0 1 0 136 7761 inv_x0
xsubckt_32_inv_x0 1 0 138 7759 inv_x0
xsubckt_1371_nand2_x0 1 0 6467 587 1749 nand2_x0
xsubckt_1573_o3_x2 0 6268 1 6269 6272 6285 o3_x2
xsubckt_1601_o2_x2 0 6240 1 6242 6301 o2_x2
xsubckt_1856_oa22_x2 0 5998 1 6225 6322 7788 oa22_x2
xsubckt_2253_nand2_x0 1 0 5698 7108 1739 nand2_x0
xsubckt_9573_sff1_x4 1 1872 0 8900 935 sff1_x4
xsubckt_9050_sff1_x4 1 1872 0 9376 1320 sff1_x4
xsubckt_8673_sff1_x4 1 1872 0 9720 1442 sff1_x4
xsubckt_6649_nand2_x0 1 0 1998 1999 712 nand2_x0
xsubckt_6480_o2_x2 0 2164 1 2165 2167 o2_x2
xsubckt_4559_mx3_x2 1 0 9711 3771 3896 1432 3820 3822 mx3_x2
xsubckt_4557_mx3_x2 1 0 9713 3771 3896 1434 3826 3828 mx3_x2
xsubckt_4555_mx3_x2 1 0 9715 3771 3896 1437 3832 3834 mx3_x2
xsubckt_4031_mx2_x2 0 3953 1 705 1488 1328 mx2_x2
xsubckt_3921_oa22_x2 0 4061 1 4114 4109 4112 oa22_x2
xsubckt_3763_ao22_x2 0 4216 1 4270 4265 4267 ao22_x2
xsubckt_3089_o2_x2 0 4878 1 4879 4880 o2_x2
xsubckt_2863_ao22_x2 0 5100 1 5104 5151 7179 ao22_x2
xsubckt_1103_nand2_x0 1 0 6721 6723 6881 nand2_x0
xsubckt_34_inv_x0 1 0 110 7757 inv_x0
xsubckt_36_inv_x0 1 0 112 7755 inv_x0
xsubckt_38_inv_x0 1 0 114 7753 inv_x0
xsubckt_1329_oa22_x2 0 6507 1 389 7044 6880 oa22_x2
xsubckt_1466_o2_x2 0 6375 1 186 215 o2_x2
xsubckt_1595_xr2_x1 6246 0 1 176 200 xr2_x1
xsubckt_1988_nand2_x0 1 0 5877 6112 6401 nand2_x0
xsubckt_9569_sff1_x4 1 1872 0 8904 1202 sff1_x4
xsubckt_9046_sff1_x4 1 1872 0 9380 517 sff1_x4
xsubckt_8219_nand4_x0 1 0 7797 3901 3903 3906 3907 nand4_x0
xsubckt_8129_mx3_x2 1 0 8698 7804 3897 1701 3856 3857 mx3_x2
xsubckt_8127_mx3_x2 1 0 8700 7804 3897 1673 3863 3864 mx3_x2
xsubckt_8125_mx3_x2 1 0 8702 7804 3897 1675 3871 3872 mx3_x2
xsubckt_8081_mx3_x2 1 0 8774 7808 3896 783 3797 3798 mx3_x2
xsubckt_7624_ao22_x2 0 7895 1 607 594 370 ao22_x2
xsubckt_5916_ao22_x2 0 2715 1 7620 2716 7613 ao22_x2
xsubckt_5825_o2_x2 0 2801 1 2802 712 o2_x2
xsubckt_5141_nxr2_x1 3363 1 0 3520 659 nxr2_x1
xsubckt_4736_nor2_x0 1 0 9618 3686 3689 nor2_x0
xsubckt_4039_mx2_x2 0 3945 1 705 1008 816 mx2_x2
xsubckt_850_nand2_x0 1 0 6963 6965 6966 nand2_x0
xsubckt_1277_nand3_x0 1 0 6556 6557 6558 6559 nand3_x0
xsubckt_1898_nand2_x0 1 0 5960 6198 6348 nand2_x0
xsubckt_9481_sff1_x4 1 1872 0 8985 1188 sff1_x4
xsubckt_9403_sff1_x4 1 1872 0 9063 1384 sff1_x4
xsubckt_8669_sff1_x4 1 1872 0 9724 1446 sff1_x4
xsubckt_8581_sff1_x4 1 1872 0 9812 1022 sff1_x4
xsubckt_7205_mx3_x2 1 0 9320 8158 3896 1145 3823 3825 mx3_x2
xsubckt_7203_mx3_x2 1 0 9322 8158 3896 1147 3829 3831 mx3_x2
xsubckt_7201_mx3_x2 1 0 9324 8158 3896 1150 3835 3837 mx3_x2
xsubckt_6812_nand2_x0 1 0 8483 8484 8485 nand2_x0
xsubckt_5625_oa22_x2 0 2952 1 1827 2959 1825 oa22_x2
xsubckt_5573_nand4_x0 1 0 2990 2999 1841 1842 1843 nand4_x0
xsubckt_4795_nand2_x0 1 0 3639 3642 1780 nand2_x0
xsubckt_3982_mx3_x2 1 0 4001 707 705 4002 1298 1458 mx3_x2
xsubckt_9477_sff1_x4 1 1872 0 8989 1162 sff1_x4
xsubckt_8503_sff1_x4 1 1872 0 9890 974 sff1_x4
xsubckt_7945_mx3_x2 1 0 8902 7816 3896 1199 3797 3798 mx3_x2
xsubckt_7943_mx3_x2 1 0 8904 7816 3896 1202 3802 3804 mx3_x2
xsubckt_7941_mx3_x2 1 0 8906 7816 3896 1204 3808 3810 mx3_x2
xsubckt_7812_mx2_x2 0 9029 1 7821 3894 1416 mx2_x2
xsubckt_7692_nand2_x0 1 0 7839 7840 7842 nand2_x0
xsubckt_7421_mx2_x2 0 9257 1 5752 9088 658 mx2_x2
xsubckt_7209_mx3_x2 1 0 9316 8158 3896 1141 3811 3813 mx3_x2
xsubckt_7207_mx3_x2 1 0 9318 8158 3896 1143 3817 3819 mx3_x2
xsubckt_7161_mx3_x2 1 0 9355 8167 3896 1306 3826 3828 mx3_x2
xsubckt_6801_nor2_x0 1 0 9388 8494 8540 nor2_x0
xsubckt_6798_ao22_x2 0 8496 1 534 532 685 ao22_x2
xsubckt_5699_oa22_x2 0 2892 1 2893 2894 704 oa22_x2
xsubckt_5544_nor2_x0 1 0 3011 3015 1850 nor2_x0
xsubckt_3984_mx3_x2 1 0 3999 707 705 4000 1234 1394 mx3_x2
xsubckt_3853_mx2_x2 0 4127 1 7215 4128 4133 mx2_x2
xsubckt_3712_xr2_x1 4266 0 1 213 685 xr2_x1
xsubckt_3464_mx2_x2 0 4510 1 705 1403 1243 mx2_x2
xsubckt_3462_mx2_x2 0 4512 1 7217 7457 7459 mx2_x2
xsubckt_3119_mx2_x2 0 4848 1 705 771 1635 mx2_x2
xsubckt_3117_mx2_x2 0 4850 1 705 1699 1571 mx2_x2
xsubckt_2763_nand2_x0 1 0 5198 5199 704 nand2_x0
xsubckt_825_oa22_x2 0 6987 1 7050 7053 7293 oa22_x2
xsubckt_311_inv_x0 1 0 1725 7480 inv_x0
xsubckt_1591_nor2_x0 1 0 6250 6251 6253 nor2_x0
xsubckt_9834_sff1_x4 1 1872 0 8642 1233 sff1_x4
xsubckt_9311_sff1_x4 1 1872 0 9150 1321 sff1_x4
xsubckt_8577_sff1_x4 1 1872 0 9816 1026 sff1_x4
xsubckt_7818_mx2_x2 0 9023 1 7821 3874 1388 mx2_x2
xsubckt_7816_mx2_x2 0 9025 1 7821 3882 1390 mx2_x2
xsubckt_7814_mx2_x2 0 9027 1 7821 3890 1404 mx2_x2
xsubckt_7528_ao22_x2 0 7970 1 1740 1742 40 ao22_x2
xsubckt_7425_mx2_x2 0 9255 1 5752 9086 656 mx2_x2
xsubckt_7423_mx2_x2 0 9256 1 5752 9087 657 mx2_x2
xsubckt_7334_nand2_x0 1 0 9286 8072 8081 nand2_x0
xsubckt_7167_mx3_x2 1 0 9349 8167 3896 1300 3808 3810 mx3_x2
xsubckt_7165_mx3_x2 1 0 9351 8167 3896 1302 3814 3816 mx3_x2
xsubckt_7163_mx3_x2 1 0 9353 8167 3896 1304 3820 3822 mx3_x2
xsubckt_7083_ao22_x2 0 8218 1 7357 710 712 ao22_x2
xsubckt_7032_mx2_x2 0 8268 1 712 1072 1040 mx2_x2
xsubckt_7030_mx2_x2 0 8270 1 712 1200 1168 mx2_x2
xsubckt_6542_nand2_x0 1 0 2103 2104 7631 nand2_x0
xsubckt_3468_mx2_x2 0 4506 1 7217 7462 7466 mx2_x2
xsubckt_2480_oa22_x2 0 5475 1 5595 5608 7687 oa22_x2
xsubckt_1145_oa22_x2 0 6681 1 6682 6686 7037 oa22_x2
xsubckt_658_a2_x2 0 7137 1 7138 7144 a2_x2
xsubckt_313_inv_x0 1 0 893 7478 inv_x0
xsubckt_315_inv_x0 1 0 797 7476 inv_x0
xsubckt_317_inv_x0 1 0 1533 7474 inv_x0
xsubckt_2052_nand3_x0 1 0 5819 5837 6408 6413 nand3_x0
xsubckt_9385_sff1_x4 1 1872 0 9076 366 sff1_x4
xsubckt_8934_sff1_x4 1 1872 0 9459 1823 sff1_x4
xsubckt_8411_sff1_x4 1 1872 0 9982 874 sff1_x4
xsubckt_7774_mx2_x2 0 9063 1 7825 3894 1384 mx2_x2
xsubckt_7429_mx2_x2 0 9253 1 5752 9084 654 mx2_x2
xsubckt_7427_mx2_x2 0 9254 1 5752 9085 655 mx2_x2
xsubckt_7169_mx3_x2 1 0 9347 8167 3896 1298 3802 3804 mx3_x2
xsubckt_7038_mx2_x2 0 8262 1 710 752 1616 mx2_x2
xsubckt_7005_ao22_x2 0 8294 1 8295 8303 711 ao22_x2
xsubckt_6634_mx3_x2 1 0 2013 712 710 2015 7447 7449 mx3_x2
xsubckt_6628_ao22_x2 0 2019 1 2030 2032 708 ao22_x2
xsubckt_6501_mx2_x2 0 2143 1 710 1022 830 mx2_x2
xsubckt_6241_mx3_x2 1 0 2397 712 710 2398 804 932 mx3_x2
xsubckt_6183_ao22_x2 0 2454 1 2455 2457 2458 ao22_x2
xsubckt_5049_nand2_x0 1 0 3447 7099 648 nand2_x0
xsubckt_4832_ao22_x2 0 3611 1 1770 3613 40 ao22_x2
xsubckt_4081_nor3_x0 1 0 3904 519 520 521 nor3_x0
xsubckt_3804_nand3_x0 1 0 4175 4176 4343 5699 nand3_x0
xsubckt_2935_mx2_x2 0 5029 1 707 902 870 mx2_x2
xsubckt_2933_mx2_x2 0 5031 1 707 1030 934 mx2_x2
xsubckt_2677_mx3_x2 1 0 5282 707 705 5283 941 1101 mx3_x2
xsubckt_929_nand2_x0 1 0 6888 672 47 nand2_x0
xsubckt_271_inv_x0 1 0 1221 7520 inv_x0
xsubckt_273_inv_x0 1 0 1093 7518 inv_x0
xsubckt_319_inv_x0 1 0 1181 7472 inv_x0
xsubckt_1537_nxr2_x1 6304 1 0 175 199 nxr2_x1
xsubckt_2280_mx3_x2 1 0 5672 712 710 5673 849 1361 mx3_x2
xsubckt_9742_sff1_x4 1 1872 0 8734 1707 sff1_x4
xsubckt_9307_sff1_x4 1 1872 0 9154 1325 sff1_x4
xsubckt_8842_sff1_x4 1 1872 0 9551 61 sff1_x4
xsubckt_8485_sff1_x4 1 1872 0 9908 1534 sff1_x4
xsubckt_8407_sff1_x4 1 1872 0 9986 878 sff1_x4
xsubckt_7778_mx2_x2 0 9059 1 7825 3882 1358 mx2_x2
xsubckt_7776_mx2_x2 0 9061 1 7825 3890 1372 mx2_x2
xsubckt_7064_nand2_x0 1 0 8236 8237 7631 nand2_x0
xsubckt_7004_a2_x2 0 8295 1 8296 8299 a2_x2
xsubckt_6983_mx3_x2 1 0 8315 711 712 8316 8319 8320 mx3_x2
xsubckt_6243_mx3_x2 1 0 2395 7628 7613 2396 2402 2404 mx3_x2
xsubckt_5883_nor2_x0 1 0 2744 2745 7620 nor2_x0
xsubckt_5640_ao22_x2 0 2941 1 2946 1821 40 ao22_x2
xsubckt_5539_a4_x2 0 3015 1 3023 1851 1852 1853 a4_x2
xsubckt_4023_a2_x2 0 3961 1 206 678 a2_x2
xsubckt_3932_ao22_x2 0 4050 1 7387 705 707 ao22_x2
xsubckt_2937_mx2_x2 0 5027 1 705 5028 5029 mx2_x2
xsubckt_2679_mx3_x2 1 0 5280 707 705 5281 1037 1165 mx3_x2
xsubckt_2548_mx2_x2 0 10083 1 5593 5409 218 mx2_x2
xsubckt_839_nand2_x0 1 0 6973 1842 589 nand2_x0
xsubckt_606_o2_x2 0 7185 1 597 598 o2_x2
xsubckt_275_inv_x0 1 0 1604 7516 inv_x0
xsubckt_277_inv_x0 1 0 1731 7514 inv_x0
xsubckt_279_inv_x0 1 0 1027 7512 inv_x0
xsubckt_2288_mx3_x2 1 0 5664 7620 7628 5665 5672 5674 mx3_x2
xsubckt_9738_sff1_x4 1 1872 0 8738 1713 sff1_x4
xsubckt_9293_sff1_x4 1 1872 0 9168 671 sff1_x4
xsubckt_9215_sff1_x4 1 1872 0 301 532 sff1_x4
xsubckt_6971_ao22_x2 0 8327 1 8328 7625 7628 ao22_x2
xsubckt_6772_oa22_x2 0 8522 1 7422 7625 7631 oa22_x2
xsubckt_6182_nand2_x0 1 0 2455 2456 712 nand2_x0
xsubckt_6135_a2_x2 0 2501 1 2502 2505 a2_x2
xsubckt_6092_nand2_x0 1 0 2543 2544 7631 nand2_x0
xsubckt_6072_mx2_x2 0 2563 1 710 1417 1257 mx2_x2
xsubckt_6070_mx2_x2 0 2565 1 710 1385 1225 mx2_x2
xsubckt_4828_ao22_x2 0 3614 1 1771 3617 40 ao22_x2
xsubckt_3809_a3_x2 1 4170 0 4171 4174 4175 a3_x2
xsubckt_3641_oa22_x2 0 4335 1 7179 4393 4336 oa22_x2
xsubckt_3408_a2_x2 0 4565 1 219 691 a2_x2
xsubckt_659_nand2_x0 1 0 7136 7138 7144 nand2_x0
xsubckt_1343_nand2_x0 1 0 6494 681 56 nand2_x0
xsubckt_2135_nand2_x0 1 0 427 5760 5784 nand2_x0
xsubckt_2400_a2_x2 0 5554 1 5555 7218 a2_x2
xsubckt_9650_sff1_x4 1 1872 0 8826 837 sff1_x4
xsubckt_9289_sff1_x4 1 1872 0 9172 697 sff1_x4
xsubckt_8838_sff1_x4 1 1872 0 9555 66 sff1_x4
xsubckt_8750_sff1_x4 1 1872 0 9643 1268 sff1_x4
xsubckt_8393_sff1_x4 1 1872 0 9992 1552 sff1_x4
xsubckt_8315_sff1_x4 1 1872 0 10070 223 sff1_x4
xsubckt_7358_a2_x2 0 8054 1 8138 572 a2_x2
xsubckt_6768_oa22_x2 0 8526 1 7631 8531 711 oa22_x2
xsubckt_6429_a2_x2 0 9396 1 2214 2256 a2_x2
xsubckt_6245_oa22_x2 0 2393 1 2394 2407 2728 oa22_x2
xsubckt_6076_mx2_x2 0 2559 1 712 2560 2561 mx2_x2
xsubckt_6074_mx2_x2 0 2561 1 710 1449 1289 mx2_x2
xsubckt_5930_mx2_x2 0 2701 1 712 2702 2703 mx2_x2
xsubckt_5667_a3_x2 1 2922 0 2927 1812 1813 a3_x2
xsubckt_5306_nxr2_x1 3211 1 0 3229 3481 nxr2_x1
xsubckt_3840_ao22_x2 0 4140 1 4141 4146 703 ao22_x2
xsubckt_3444_nand3_x0 1 0 4529 4530 4689 5699 nand3_x0
xsubckt_2829_oa22_x2 0 5133 1 5134 5140 7218 oa22_x2
xsubckt_2758_xr2_x1 5203 0 1 201 673 xr2_x1
xsubckt_2741_oa22_x2 0 5219 1 5220 5225 7215 oa22_x2
xsubckt_2539_a2_x2 0 5417 1 5418 7179 a2_x2
xsubckt_2505_ao22_x2 0 5451 1 5452 5456 7218 ao22_x2
xsubckt_1049_oa22_x2 0 6773 1 6799 6794 6798 oa22_x2
xsubckt_1336_a2_x2 0 6500 1 210 1739 a2_x2
xsubckt_1952_a3_x2 1 5910 0 5911 5912 5913 a3_x2
xsubckt_2045_nand2_x0 1 0 5825 5826 6408 nand2_x0
xsubckt_9646_sff1_x4 1 1872 0 8830 811 sff1_x4
xsubckt_9123_sff1_x4 1 1872 0 9335 1131 sff1_x4
xsubckt_8389_sff1_x4 1 1872 0 9996 1557 sff1_x4
xsubckt_7701_ao22_x2 0 7832 1 7647 7954 3448 ao22_x2
xsubckt_6967_ao22_x2 0 8331 1 8332 8334 7613 ao22_x2
xsubckt_6962_nand2_x0 1 0 8336 8337 711 nand2_x0
xsubckt_6872_nand2_x0 1 0 8424 8425 711 nand2_x0
xsubckt_5950_a2_x2 0 2682 1 7568 710 a2_x2
xsubckt_5775_a2_x2 0 2848 1 5605 7782 a2_x2
xsubckt_4813_nor2_x0 1 0 3625 3627 3631 nor2_x0
xsubckt_4060_nand2_x0 1 0 3924 3925 7219 nand2_x0
xsubckt_3488_a2_x2 0 4486 1 4492 703 a2_x2
xsubckt_2579_a2_x2 0 5378 1 5379 5380 a2_x2
xsubckt_1443_xr2_x1 6398 0 1 184 213 xr2_x1
xsubckt_1590_nand3_x0 1 0 6251 6252 6256 6257 nand3_x0
xsubckt_9197_sff1_x4 1 1872 0 9261 668 sff1_x4
xsubckt_8746_sff1_x4 1 1872 0 9647 1272 sff1_x4
xsubckt_6958_a2_x2 0 8340 1 7390 710 a2_x2
xsubckt_5990_nand2_x0 1 0 2643 2644 2645 nand2_x0
xsubckt_4887_nor2_x0 1 0 9583 3569 3570 nor2_x0
xsubckt_4663_nand4_x0 1 0 3744 3749 3754 3763 1751 nand4_x0
xsubckt_4644_ao22_x2 0 3758 1 1806 3763 40 ao22_x2
xsubckt_3977_a2_x2 0 4006 1 208 680 a2_x2
xsubckt_3617_nand2_x0 1 0 4359 4360 4365 nand2_x0
xsubckt_3162_o2_x2 0 4806 1 705 930 o2_x2
xsubckt_1324_o2_x2 0 6512 1 682 57 o2_x2
xsubckt_1837_oa22_x2 0 6015 1 198 228 574 oa22_x2
xsubckt_1943_nand2_x0 1 0 5919 5920 574 nand2_x0
xsubckt_9554_sff1_x4 1 1872 0 8919 1218 sff1_x4
xsubckt_9119_sff1_x4 1 1872 0 9339 1137 sff1_x4
xsubckt_9031_sff1_x4 1 1872 0 9395 191 sff1_x4
xsubckt_7306_nand2_x0 1 0 8093 8138 581 nand2_x0
xsubckt_5288_nxr2_x1 3228 1 0 3235 3483 nxr2_x1
xsubckt_4840_nand2_x0 1 0 3605 3606 3615 nand2_x0
xsubckt_4814_o2_x2 0 3624 1 3627 3631 o2_x2
xsubckt_4230_mx2_x2 0 10016 1 3794 3874 1548 mx2_x2
xsubckt_2702_o2_x2 0 5258 1 202 674 o2_x2
xsubckt_2487_ao22_x2 0 5469 1 5470 5471 704 ao22_x2
xsubckt_1232_nand3_x0 1 0 6599 6619 6620 6623 nand3_x0
xsubckt_1853_nand2_x0 1 0 6000 6112 6321 nand2_x0
xsubckt_8654_sff1_x4 1 1872 0 9739 1076 sff1_x4
xsubckt_7683_ao22_x2 0 9164 1 7850 7847 7848 ao22_x2
xsubckt_6424_nand2_x0 1 0 2218 2219 7620 nand2_x0
xsubckt_4974_mx2_x2 0 3504 1 5753 3849 134 mx2_x2
xsubckt_4970_mx2_x2 0 3507 1 5753 3852 135 mx2_x2
xsubckt_4190_mx2_x2 0 3819 1 518 91 1887 mx2_x2
xsubckt_3347_nand2_x0 1 0 4625 4626 4627 nand2_x0
xsubckt_2844_ao22_x2 0 5118 1 7215 5127 5119 ao22_x2
xsubckt_2555_nand2_x0 1 0 5402 5403 7216 nand2_x0
xsubckt_750_a4_x2 0 7056 1 7071 7072 7073 7075 a4_x2
xsubckt_1638_o2_x2 0 6203 1 6204 6324 o2_x2
xsubckt_9462_sff1_x4 1 1872 0 9004 1398 sff1_x4
xsubckt_9027_sff1_x4 1 1872 0 9399 195 sff1_x4
xsubckt_8153_mx2_x2 0 8676 1 7801 3892 1671 mx2_x2
xsubckt_7679_ao22_x2 0 7850 1 7953 8018 359 ao22_x2
xsubckt_7325_nor2_x0 1 0 8080 358 357 nor2_x0
xsubckt_6244_nand2_x0 1 0 2394 2395 7620 nand2_x0
xsubckt_5362_nand2_x0 1 0 9518 3159 3179 nand2_x0
xsubckt_5360_ao22_x2 0 3160 1 3161 3163 3175 ao22_x2
xsubckt_5249_oa22_x2 0 3264 1 3270 3271 3272 oa22_x2
xsubckt_5168_nor2_x0 1 0 3338 3339 3340 nor2_x0
xsubckt_5161_oa22_x2 0 3345 1 7680 3514 7167 oa22_x2
xsubckt_4978_mx2_x2 0 3501 1 5753 3846 133 mx2_x2
xsubckt_4710_oa22_x2 0 3705 1 3718 3745 1801 oa22_x2
xsubckt_4570_nand2_x0 1 0 3767 3769 3787 nand2_x0
xsubckt_4194_mx2_x2 0 3816 1 518 90 1886 mx2_x2
xsubckt_3895_nor2_x0 1 0 4086 4087 7216 nor2_x0
xsubckt_3312_mx2_x2 0 4659 1 703 4660 4663 mx2_x2
xsubckt_3310_mx2_x2 0 4661 1 705 927 799 mx2_x2
xsubckt_3052_mx3_x2 1 0 4914 7215 7218 4915 4926 4932 mx3_x2
xsubckt_2030_oa22_x2 0 5839 1 5840 5852 6393 oa22_x2
xsubckt_2317_ao22_x2 0 5636 1 5637 5639 709 ao22_x2
xsubckt_2375_nand2_x0 1 0 5579 5580 5583 nand2_x0
xsubckt_9458_sff1_x4 1 1872 0 9008 1402 sff1_x4
xsubckt_8562_sff1_x4 1 1872 0 9831 1487 sff1_x4
xsubckt_8157_mx2_x2 0 8672 1 7801 3878 1645 mx2_x2
xsubckt_8155_mx2_x2 0 8674 1 7801 3886 1649 mx2_x2
xsubckt_7753_mx3_x2 1 0 9114 7828 3896 1059 3850 3852 mx3_x2
xsubckt_7751_mx3_x2 1 0 9116 7828 3897 1061 3856 3857 mx3_x2
xsubckt_7639_nand4_x0 1 0 7882 7883 7951 7957 8140 nand4_x0
xsubckt_6937_oa22_x2 0 8360 1 7631 8361 7628 oa22_x2
xsubckt_5805_ao22_x2 0 2821 1 2822 7620 711 ao22_x2
xsubckt_5448_nand3_x0 1 0 3081 1859 1870 1871 nand3_x0
xsubckt_5272_nand2_x0 1 0 9524 3243 3254 nand2_x0
xsubckt_4198_mx2_x2 0 3813 1 518 89 1885 mx2_x2
xsubckt_3661_mx2_x2 0 4316 1 705 760 1624 mx2_x2
xsubckt_3318_mx2_x2 0 4653 1 705 767 1631 mx2_x2
xsubckt_3316_mx2_x2 0 4655 1 705 1215 1087 mx2_x2
xsubckt_2752_ao22_x2 0 5208 1 5585 5216 5209 ao22_x2
xsubckt_899_nand2_x0 1 0 6916 1839 589 nand2_x0
xsubckt_510_inv_x0 1 0 402 7281 inv_x0
xsubckt_1211_nand4_x0 1 0 6619 6622 6638 6641 6660 nand4_x0
xsubckt_2107_nand2_x0 1 0 5774 419 308 nand2_x0
xsubckt_9893_sff1_x4 1 1872 0 8583 1616 sff1_x4
xsubckt_9815_sff1_x4 1 1872 0 8661 1664 sff1_x4
xsubckt_9370_sff1_x4 1 1872 0 9091 351 sff1_x4
xsubckt_8993_sff1_x4 1 1872 0 9432 508 sff1_x4
xsubckt_8558_sff1_x4 1 1872 0 9835 1492 sff1_x4
xsubckt_7759_mx3_x2 1 0 9108 7828 3896 1053 3832 3834 mx3_x2
xsubckt_7757_mx3_x2 1 0 9110 7828 3896 1055 3838 3840 mx3_x2
xsubckt_7755_mx3_x2 1 0 9112 7828 3896 1057 3844 3846 mx3_x2
xsubckt_7231_mx2_x2 0 9310 1 5752 8148 594 mx2_x2
xsubckt_7019_mx3_x2 1 0 8280 7613 7620 8281 8288 8291 mx3_x2
xsubckt_5599_nor2_x0 1 0 2971 2975 1833 nor2_x0
xsubckt_5592_oa22_x2 0 2976 1 1836 2983 1835 oa22_x2
xsubckt_4130_nxr2_x1 3864 1 0 3869 7729 nxr2_x1
xsubckt_3669_mx2_x2 0 4308 1 706 1176 1112 mx2_x2
xsubckt_3330_nand2_x0 1 0 4641 7152 7265 nand2_x0
xsubckt_3276_mx2_x2 0 4694 1 7216 4695 4697 mx2_x2
xsubckt_3274_mx2_x2 0 4696 1 705 1216 1088 mx2_x2
xsubckt_3272_mx2_x2 0 4698 1 705 1504 1344 mx2_x2
xsubckt_2523_mx3_x2 1 0 5433 707 705 5434 1532 1660 mx3_x2
xsubckt_751_a2_x2 0 7055 1 7056 531 a2_x2
xsubckt_123_inv_x0 1 0 358 7668 inv_x0
xsubckt_121_inv_x0 1 0 355 7670 inv_x0
xsubckt_512_inv_x0 1 0 200 7279 inv_x0
xsubckt_514_inv_x0 1 0 228 7277 inv_x0
xsubckt_516_inv_x0 1 0 226 7275 inv_x0
xsubckt_9889_sff1_x4 1 1872 0 8587 1621 sff1_x4
xsubckt_9366_sff1_x4 1 1872 0 9095 377 sff1_x4
xsubckt_8915_sff1_x4 1 1872 0 9478 1844 sff1_x4
xsubckt_8470_sff1_x4 1 1872 0 9923 1521 sff1_x4
xsubckt_7704_a4_x2 0 7830 1 3766 3901 3903 3906 a4_x2
xsubckt_7235_mx2_x2 0 9309 1 5752 8145 607 mx2_x2
xsubckt_6845_oa22_x2 0 8450 1 8451 8464 2728 oa22_x2
xsubckt_6442_mx3_x2 1 0 2201 712 710 2202 1535 1663 mx3_x2
xsubckt_5016_a3_x2 1 3473 0 40 59 7780 a3_x2
xsubckt_4703_a4_x2 0 3712 1 1745 1744 1805 1804 a4_x2
xsubckt_3873_xr2_x1 4108 0 1 210 682 xr2_x1
xsubckt_3137_xr2_x1 4831 0 1 224 696 xr2_x1
xsubckt_1045_nand2_x0 1 0 6777 697 72 nand2_x0
xsubckt_129_inv_x0 1 0 652 7662 inv_x0
xsubckt_127_inv_x0 1 0 364 7664 inv_x0
xsubckt_125_inv_x0 1 0 360 7666 inv_x0
xsubckt_470_inv_x0 1 0 95 7321 inv_x0
xsubckt_472_inv_x0 1 0 94 7319 inv_x0
xsubckt_518_inv_x0 1 0 224 7273 inv_x0
xsubckt_1507_a4_x2 0 6334 1 6337 6342 6348 6353 a4_x2
xsubckt_1568_nor2_x0 1 0 6273 6274 6280 nor2_x0
xsubckt_1596_nxr2_x1 6245 1 0 176 200 nxr2_x1
xsubckt_9723_sff1_x4 1 1872 0 8753 763 sff1_x4
xsubckt_9200_sff1_x4 1 1872 0 9258 665 sff1_x4
xsubckt_8989_sff1_x4 1 1872 0 9436 512 sff1_x4
xsubckt_8466_sff1_x4 1 1872 0 9927 719 sff1_x4
xsubckt_7653_oa22_x2 0 9170 1 7871 7875 7876 oa22_x2
xsubckt_6844_nand2_x0 1 0 8451 8452 7628 nand2_x0
xsubckt_6706_mx2_x2 0 1943 1 710 1144 984 mx2_x2
xsubckt_6609_ao22_x2 0 2037 1 534 532 689 ao22_x2
xsubckt_6055_mx3_x2 1 0 2579 712 710 2580 842 1354 mx3_x2
xsubckt_5505_a3_x2 1 9494 0 3040 3041 40 a3_x2
xsubckt_5341_nand3_x0 1 0 3179 40 122 7780 nand3_x0
xsubckt_5264_ao22_x2 0 3250 1 600 3251 644 ao22_x2
xsubckt_5036_a3_x2 1 3458 0 40 53 7780 a3_x2
xsubckt_4147_a3_x2 1 3851 0 3858 73 72 a3_x2
xsubckt_3857_nand2_x0 1 0 4123 7153 7261 nand2_x0
xsubckt_2975_nand2_x0 1 0 4990 4991 707 nand2_x0
xsubckt_2457_oa22_x2 0 5498 1 1159 706 705 oa22_x2
xsubckt_792_nand2_x0 1 0 7018 1844 589 nand2_x0
xsubckt_474_inv_x0 1 0 93 7317 inv_x0
xsubckt_476_inv_x0 1 0 92 7315 inv_x0
xsubckt_478_inv_x0 1 0 91 7313 inv_x0
xsubckt_1915_nand2_x0 1 0 5944 6116 6338 nand2_x0
xsubckt_2000_nand2_x0 1 0 5866 6112 6406 nand2_x0
xsubckt_9797_sff1_x4 1 1872 0 8679 1680 sff1_x4
xsubckt_9274_sff1_x4 1 1872 0 9187 681 sff1_x4
xsubckt_8823_sff1_x4 1 1872 0 9570 51 sff1_x4
xsubckt_8300_sff1_x4 1 1872 0 10085 230 sff1_x4
xsubckt_7546_nand2_x0 1 0 7957 8018 352 nand2_x0
xsubckt_6662_mx2_x2 0 1986 1 712 985 953 mx2_x2
xsubckt_5695_ao22_x2 0 2896 1 1263 707 705 ao22_x2
xsubckt_5144_a2_x2 0 3360 1 3362 3363 a2_x2
xsubckt_4362_a3_x2 1 3783 0 519 520 521 a3_x2
xsubckt_2885_nand2_x0 1 0 5078 5079 7218 nand2_x0
xsubckt_788_nand3_x0 1 0 7022 7023 7024 7026 nand3_x0
xsubckt_1587_a4_x2 0 6254 1 6262 6286 6292 6296 a4_x2
xsubckt_1825_nand2_x0 1 0 6026 6247 6306 nand2_x0
xsubckt_9719_sff1_x4 1 1872 0 8757 768 sff1_x4
xsubckt_9631_sff1_x4 1 1872 0 8842 852 sff1_x4
xsubckt_8897_sff1_x4 1 1872 0 9496 1864 sff1_x4
xsubckt_8819_sff1_x4 1 1872 0 9574 1747 sff1_x4
xsubckt_8374_sff1_x4 1 1872 0 10011 1573 sff1_x4
xsubckt_7126_oa22_x2 0 8176 1 8177 8180 517 oa22_x2
xsubckt_6666_mx2_x2 0 1982 1 712 1209 1177 mx2_x2
xsubckt_6664_mx2_x2 0 1984 1 710 1985 1986 mx2_x2
xsubckt_6277_mx2_x2 0 2362 1 710 1507 1347 mx2_x2
xsubckt_6093_a2_x2 0 2542 1 7536 710 a2_x2
xsubckt_5915_mx3_x2 1 0 2716 712 710 2717 1517 1645 mx3_x2
xsubckt_5633_a2_x2 0 9459 1 2947 2948 a2_x2
xsubckt_5002_mx2_x2 0 3483 1 5753 3828 126 mx2_x2
xsubckt_4704_a2_x2 0 3711 1 3712 3713 a2_x2
xsubckt_4676_a3_x2 1 3734 0 3739 1745 1744 a3_x2
xsubckt_4656_a3_x2 1 9633 0 3750 3751 40 a3_x2
xsubckt_3821_ao22_x2 0 4159 1 4215 4212 4213 ao22_x2
xsubckt_3521_a2_x2 0 4454 1 4455 4456 a2_x2
xsubckt_2632_a2_x2 0 5326 1 5327 7216 a2_x2
xsubckt_1254_a2_x2 0 6578 1 7143 1855 a2_x2
xsubckt_1528_a2_x2 0 6313 1 198 228 a2_x2
xsubckt_2417_a2_x2 0 5537 1 5538 7179 a2_x2
xsubckt_9182_sff1_x4 1 1872 0 9276 592 sff1_x4
xsubckt_8731_sff1_x4 1 1872 0 9662 1258 sff1_x4
xsubckt_7980_a2_x2 0 7812 1 3793 3900 a2_x2
xsubckt_6856_a2_x2 0 8440 1 8441 7625 a2_x2
xsubckt_6661_oa22_x2 0 1987 1 40 1741 186 oa22_x2
xsubckt_6279_mx2_x2 0 2360 1 710 1731 899 mx2_x2
xsubckt_5744_mx2_x2 0 9439 1 2856 448 485 mx2_x2
xsubckt_5742_mx2_x2 0 9441 1 2856 450 487 mx2_x2
xsubckt_5740_mx2_x2 0 9443 1 2856 452 489 mx2_x2
xsubckt_5498_a2_x2 0 9496 1 3045 3046 a2_x2
xsubckt_5006_mx2_x2 0 3480 1 5753 3825 125 mx2_x2
xsubckt_4784_a2_x2 0 9607 1 3648 3651 a2_x2
xsubckt_4602_mx3_x2 1 0 9671 3768 3896 1103 3797 3798 mx3_x2
xsubckt_4600_mx3_x2 1 0 9673 3768 3896 1106 3802 3804 mx3_x2
xsubckt_4569_a2_x2 0 3768 1 3769 3787 a2_x2
xsubckt_2954_nand3_x0 1 0 5010 5011 5159 7104 nand3_x0
xsubckt_1251_xr2_x1 6581 0 1 686 61 xr2_x1
xsubckt_2273_oa22_x2 0 5679 1 5680 710 712 oa22_x2
xsubckt_9627_sff1_x4 1 1872 0 8846 856 sff1_x4
xsubckt_9104_sff1_x4 1 1872 0 1923 1891 sff1_x4
xsubckt_8727_sff1_x4 1 1872 0 9666 1262 sff1_x4
xsubckt_5879_mx3_x2 1 0 2748 712 710 2749 1063 1191 mx3_x2
xsubckt_5748_mx2_x2 0 9435 1 2856 474 511 mx2_x2
xsubckt_5746_mx2_x2 0 9437 1 2856 476 513 mx2_x2
xsubckt_4560_mx3_x2 1 0 9710 3771 3896 1431 3817 3819 mx3_x2
xsubckt_4217_mx3_x2 1 0 10024 3899 3896 1584 3799 3801 mx3_x2
xsubckt_4213_mx3_x2 1 0 10025 3899 3896 1586 3802 3804 mx3_x2
xsubckt_3660_nand2_x0 1 0 4317 4318 707 nand2_x0
xsubckt_3314_o2_x2 0 4657 1 4658 7218 o2_x2
xsubckt_3169_oa22_x2 0 4799 1 1282 705 707 oa22_x2
xsubckt_1242_o2_x2 0 6589 1 6590 6591 o2_x2
xsubckt_2347_nand2_x0 1 0 5607 7183 7192 nand2_x0
xsubckt_9535_sff1_x4 1 1872 0 10103 1741 sff1_x4
xsubckt_9178_sff1_x4 1 1872 0 9280 579 sff1_x4
xsubckt_9090_sff1_x4 1 1872 0 1908 1876 sff1_x4
xsubckt_8130_mx3_x2 1 0 8697 7804 3896 1700 3853 3855 mx3_x2
xsubckt_7284_o2_x2 0 9300 1 8108 8110 o2_x2
xsubckt_6355_o2_x2 0 2286 1 2287 7631 o2_x2
xsubckt_6036_nand2_x0 1 0 2598 2599 7631 nand2_x0
xsubckt_4957_mx3_x2 1 0 3517 5754 518 7759 7340 7341 mx3_x2
xsubckt_4953_mx3_x2 1 0 3520 5754 518 7758 7342 7343 mx3_x2
xsubckt_4566_mx3_x2 1 0 9704 3771 3896 1424 3799 3801 mx3_x2
xsubckt_4564_mx3_x2 1 0 9706 3771 3896 1427 3805 3807 mx3_x2
xsubckt_4562_mx3_x2 1 0 9708 3771 3896 1429 3811 3813 mx3_x2
xsubckt_4173_mx3_x2 1 0 10035 3899 3896 1597 3832 3834 mx3_x2
xsubckt_3608_o2_x2 0 4368 1 4369 707 o2_x2
xsubckt_3368_ao22_x2 0 4604 1 7482 705 707 ao22_x2
xsubckt_3159_o2_x2 0 4809 1 705 1026 o2_x2
xsubckt_1107_nand2_x0 1 0 6717 587 1765 nand2_x0
xsubckt_41_inv_x0 1 0 52 7750 inv_x0
xsubckt_43_inv_x0 1 0 55 7748 inv_x0
xsubckt_45_inv_x0 1 0 57 7746 inv_x0
xsubckt_1765_nxr2_x1 6080 1 0 6081 6262 nxr2_x1
xsubckt_1818_oa22_x2 0 6032 1 6034 6036 6305 oa22_x2
xsubckt_9012_sff1_x4 1 1872 0 9413 481 sff1_x4
xsubckt_8635_sff1_x4 1 1872 0 9758 1066 sff1_x4
xsubckt_8136_mx3_x2 1 0 8691 7804 3896 1694 3835 3837 mx3_x2
xsubckt_8134_mx3_x2 1 0 8693 7804 3896 1696 3841 3843 mx3_x2
xsubckt_8132_mx3_x2 1 0 8695 7804 3896 1698 3847 3849 mx3_x2
xsubckt_7664_ao22_x2 0 7862 1 7953 8018 356 ao22_x2
xsubckt_6463_nand3_x0 1 0 2180 2182 2184 7620 nand3_x0
xsubckt_5956_ao22_x2 0 2676 1 7625 1580 2677 ao22_x2
xsubckt_5887_o3_x2 0 2740 1 2742 2743 2785 o3_x2
xsubckt_5181_nxr2_x1 3326 1 0 3344 3511 nxr2_x1
xsubckt_4439_mx2_x2 0 9825 1 3776 3878 1005 mx2_x2
xsubckt_4437_mx2_x2 0 9827 1 3776 3886 1009 mx2_x2
xsubckt_4435_mx2_x2 0 9829 1 3776 3892 1031 mx2_x2
xsubckt_4177_mx3_x2 1 0 10034 3899 3896 1595 3829 3831 mx3_x2
xsubckt_4046_mx2_x2 0 3938 1 707 3939 3940 mx2_x2
xsubckt_4044_mx2_x2 0 3940 1 705 1648 1520 mx2_x2
xsubckt_3919_nand2_x0 1 0 4063 209 681 nand2_x0
xsubckt_3799_ao22_x2 0 4180 1 706 4184 4181 ao22_x2
xsubckt_3668_o2_x2 0 4309 1 4310 4312 o2_x2
xsubckt_2594_nand3_x0 1 0 5363 5365 5595 5608 nand3_x0
xsubckt_944_nand2_x0 1 0 6873 588 1745 nand2_x0
xsubckt_47_inv_x0 1 0 59 7744 inv_x0
xsubckt_49_inv_x0 1 0 61 7742 inv_x0
xsubckt_1281_oa22_x2 0 6552 1 6719 6561 6553 oa22_x2
xsubckt_1576_o2_x2 0 6265 1 420 204 o2_x2
xsubckt_2077_nand2_x0 1 0 5797 7043 7053 nand2_x0
xsubckt_9443_sff1_x4 1 1872 0 9023 1388 sff1_x4
xsubckt_9086_sff1_x4 1 1872 0 1924 1892 sff1_x4
xsubckt_9008_sff1_x4 1 1872 0 9417 491 sff1_x4
xsubckt_8138_mx3_x2 1 0 8689 7804 3896 1691 3829 3831 mx3_x2
xsubckt_8094_mx3_x2 1 0 8763 7806 3897 774 3859 3860 mx3_x2
xsubckt_7212_mx3_x2 1 0 9313 8158 3896 1138 3802 3804 mx3_x2
xsubckt_7210_mx3_x2 1 0 9315 8158 3896 1140 3808 3810 mx3_x2
xsubckt_6816_nand2_x0 1 0 8479 8480 8483 nand2_x0
xsubckt_5177_nxr2_x1 3330 1 0 3511 669 nxr2_x1
xsubckt_5103_nxr2_x1 3398 1 0 3529 662 nxr2_x1
xsubckt_4048_mx2_x2 0 3936 1 705 752 1616 mx2_x2
xsubckt_3122_mx2_x2 0 4845 1 703 4846 4851 mx2_x2
xsubckt_2974_o2_x2 0 4991 1 705 1669 o2_x2
xsubckt_1122_nor2_x0 1 0 6703 6705 6706 nor2_x0
xsubckt_9800_sff1_x4 1 1872 0 8676 1671 sff1_x4
xsubckt_8543_sff1_x4 1 1872 0 9850 1508 sff1_x4
xsubckt_8098_mx3_x2 1 0 8759 7806 3896 770 3847 3849 mx3_x2
xsubckt_8096_mx3_x2 1 0 8761 7806 3896 772 3853 3855 mx3_x2
xsubckt_7572_ao22_x2 0 7936 1 607 594 358 ao22_x2
xsubckt_7214_mx3_x2 1 0 9311 8158 3896 1135 3797 3798 mx3_x2
xsubckt_7137_ao22_x2 0 9378 1 8171 8170 8168 ao22_x2
xsubckt_6105_nand3_x0 1 0 2530 2531 2538 7613 nand3_x0
xsubckt_5864_ao22_x2 0 2763 1 2767 2766 2764 ao22_x2
xsubckt_5223_nand3_x0 1 0 3288 40 132 7780 nand3_x0
xsubckt_3649_nand2_x0 1 0 4328 214 686 nand2_x0
xsubckt_3471_mx2_x2 0 4503 1 7217 7464 7468 mx2_x2
xsubckt_3259_mx3_x2 1 0 4711 707 705 4712 1248 1408 mx3_x2
xsubckt_2534_oa22_x2 0 5422 1 5540 5487 5489 oa22_x2
xsubckt_644_nor4_x0 1 0 7151 581 580 582 579 nor4_x0
xsubckt_9874_sff1_x4 1 1872 0 8602 1637 sff1_x4
xsubckt_9439_sff1_x4 1 1872 0 9027 1404 sff1_x4
xsubckt_9351_sff1_x4 1 1872 0 9110 1055 sff1_x4
xsubckt_8900_sff1_x4 1 1872 0 9493 1861 sff1_x4
xsubckt_7958_mx3_x2 1 0 8891 7814 3897 934 3859 3860 mx3_x2
xsubckt_7956_mx3_x2 1 0 8893 7814 3897 906 3867 3868 mx3_x2
xsubckt_7338_nand2_x0 1 0 9285 8069 8071 nand2_x0
xsubckt_7170_mx3_x2 1 0 9346 8167 3896 1296 3799 3801 mx3_x2
xsubckt_6830_oa22_x2 0 8465 1 8466 8473 709 oa22_x2
xsubckt_5772_ao22_x2 0 2851 1 6142 6119 2852 ao22_x2
xsubckt_5664_nand2_x0 1 0 2924 2927 1813 nand2_x0
xsubckt_5650_nand4_x0 1 0 2934 2943 1818 1819 1820 nand4_x0
xsubckt_5337_ao22_x2 0 3182 1 3188 3186 3183 ao22_x2
xsubckt_5050_oa22_x2 0 3446 1 3543 3447 3449 oa22_x2
xsubckt_4872_nand2_x0 1 0 3581 3584 3595 nand2_x0
xsubckt_3629_ao22_x2 0 4347 1 4348 4351 7218 ao22_x2
xsubckt_3541_ao22_x2 0 4434 1 7453 7218 705 ao22_x2
xsubckt_3473_mx2_x2 0 4501 1 707 4502 4503 mx2_x2
xsubckt_2726_mx3_x2 1 0 5234 707 705 5235 1516 1644 mx3_x2
xsubckt_1000_nand2_x0 1 0 169 6820 6834 nand2_x0
xsubckt_943_a2_x2 0 6874 1 7143 1809 a2_x2
xsubckt_923_nand3_x0 1 0 6893 6894 6895 6896 nand3_x0
xsubckt_903_a2_x2 0 6912 1 202 1739 a2_x2
xsubckt_584_nand2_x0 1 0 7207 344 343 nand2_x0
xsubckt_320_inv_x0 1 0 1085 7471 inv_x0
xsubckt_322_inv_x0 1 0 1723 7469 inv_x0
xsubckt_324_inv_x0 1 0 1019 7467 inv_x0
xsubckt_2085_oa22_x2 0 5791 1 7685 308 7238 oa22_x2
xsubckt_8974_sff1_x4 1 1872 0 151 88 sff1_x4
xsubckt_8539_sff1_x4 1 1872 0 9854 1482 sff1_x4
xsubckt_8451_sff1_x4 1 1872 0 9942 736 sff1_x4
xsubckt_8082_a4_x2 0 7806 1 3790 3901 3903 3906 a4_x2
xsubckt_7568_ao22_x2 0 7939 1 607 594 357 ao22_x2
xsubckt_7045_mx2_x2 0 8255 1 7625 7381 7383 mx2_x2
xsubckt_6381_oa22_x2 0 2260 1 2261 2274 2728 oa22_x2
xsubckt_3808_nand3_x0 1 0 4171 4172 4341 7104 nand3_x0
xsubckt_2930_nand2_x0 1 0 5034 5035 7218 nand2_x0
xsubckt_2728_mx3_x2 1 0 5232 707 705 5233 1580 716 mx3_x2
xsubckt_2684_mx3_x2 1 0 5275 707 705 5276 1581 717 mx3_x2
xsubckt_2682_mx3_x2 1 0 5277 707 705 5278 1517 1645 mx3_x2
xsubckt_280_inv_x0 1 0 931 7511 inv_x0
xsubckt_326_inv_x0 1 0 891 7465 inv_x0
xsubckt_328_inv_x0 1 0 827 7463 inv_x0
xsubckt_9782_sff1_x4 1 1872 0 8694 1697 sff1_x4
xsubckt_9347_sff1_x4 1 1872 0 9114 1059 sff1_x4
xsubckt_7261_a3_x2 1 8124 0 7658 372 371 a3_x2
xsubckt_6905_mx2_x2 0 8392 1 711 8393 8396 mx2_x2
xsubckt_6903_mx2_x2 0 8394 1 712 756 724 mx2_x2
xsubckt_6901_mx2_x2 0 8396 1 710 8397 8398 mx2_x2
xsubckt_6826_oa22_x2 0 8469 1 1270 710 712 oa22_x2
xsubckt_5550_a4_x2 0 3007 1 3015 1847 1849 1850 a4_x2
xsubckt_5245_ao22_x2 0 3267 1 3268 3269 3273 ao22_x2
xsubckt_4778_nand3_x0 1 0 3652 3657 1786 1785 nand3_x0
xsubckt_3692_nor2_x0 1 0 4285 4286 4288 nor2_x0
xsubckt_3542_nand2_x0 1 0 4433 4434 4435 nand2_x0
xsubckt_2948_mx2_x2 0 5016 1 705 1222 1094 mx2_x2
xsubckt_2946_mx2_x2 0 5018 1 705 1158 998 mx2_x2
xsubckt_2557_mx2_x2 0 5400 1 705 1713 881 mx2_x2
xsubckt_2553_mx2_x2 0 5404 1 705 1457 1297 mx2_x2
xsubckt_769_oa22_x2 0 7040 1 7041 7126 7643 oa22_x2
xsubckt_282_inv_x0 1 0 867 7509 inv_x0
xsubckt_284_inv_x0 1 0 803 7507 inv_x0
xsubckt_286_inv_x0 1 0 1539 7505 inv_x0
xsubckt_1437_nand2_x0 1 0 6404 183 212 nand2_x0
xsubckt_9704_sff1_x4 1 1872 0 8772 775 sff1_x4
xsubckt_8882_sff1_x4 1 1872 0 9511 1871 sff1_x4
xsubckt_8804_sff1_x4 1 1872 0 9589 1764 sff1_x4
xsubckt_8447_sff1_x4 1 1872 0 9946 740 sff1_x4
xsubckt_7321_nand2_x0 1 0 9288 8083 8084 nand2_x0
xsubckt_6994_mx3_x2 1 0 8305 712 710 8306 1234 1394 mx3_x2
xsubckt_6992_mx3_x2 1 0 8307 712 710 8308 946 1106 mx3_x2
xsubckt_6907_mx2_x2 0 8390 1 710 1492 1332 mx2_x2
xsubckt_5649_a4_x2 0 2935 1 2943 1818 1819 1820 a4_x2
xsubckt_5483_a3_x2 1 9500 0 3056 3057 40 a3_x2
xsubckt_5438_nxr2_x1 3088 1 0 3098 3453 nxr2_x1
xsubckt_5403_oa22_x2 0 3121 1 7680 3460 7167 oa22_x2
xsubckt_5126_nand2_x0 1 0 3377 3523 7655 nand2_x0
xsubckt_4780_ao22_x2 0 3651 1 1783 3653 40 ao22_x2
xsubckt_2714_nor2_x0 1 0 5246 5247 703 nor2_x0
xsubckt_2559_mx2_x2 0 5398 1 7219 5399 5400 mx2_x2
xsubckt_1112_a2_x2 0 6712 1 223 1739 a2_x2
xsubckt_288_inv_x0 1 0 1443 7503 inv_x0
xsubckt_1257_nand2_x0 1 0 6575 1820 589 nand2_x0
xsubckt_1954_nand3_x0 1 0 5909 5929 6360 6365 nand3_x0
xsubckt_2139_nand2_x0 1 0 425 5758 5776 nand2_x0
xsubckt_2416_xr2_x1 5538 0 1 702 230 xr2_x1
xsubckt_9778_sff1_x4 1 1872 0 8698 1701 sff1_x4
xsubckt_9690_sff1_x4 1 1872 0 8786 797 sff1_x4
xsubckt_9612_sff1_x4 1 1872 0 8861 842 sff1_x4
xsubckt_9255_sff1_x4 1 1872 0 9206 323 sff1_x4
xsubckt_8878_sff1_x4 1 1872 0 9515 119 sff1_x4
xsubckt_8355_sff1_x4 1 1872 0 10030 1591 sff1_x4
xsubckt_7643_a2_x2 0 7879 1 669 600 a2_x2
xsubckt_6869_mx2_x2 0 8427 1 7625 7403 7405 mx2_x2
xsubckt_6476_mx2_x2 0 2168 1 712 1214 1182 mx2_x2
xsubckt_6474_mx2_x2 0 2170 1 712 990 958 mx2_x2
xsubckt_6472_mx2_x2 0 2172 1 712 1150 1118 mx2_x2
xsubckt_6129_mx2_x2 0 2507 1 710 1030 838 mx2_x2
xsubckt_5531_a2_x2 0 9487 1 3021 3022 a2_x2
xsubckt_4013_o3_x2 0 3970 1 4020 4124 5698 o3_x2
xsubckt_3603_oa22_x2 0 4373 1 707 4374 703 oa22_x2
xsubckt_3518_a2_x2 0 4457 1 4458 4459 a2_x2
xsubckt_3362_nand2_x0 1 0 4610 4611 4612 nand2_x0
xsubckt_3244_a2_x2 0 4726 1 222 694 a2_x2
xsubckt_3193_nxr2_x1 4776 1 0 223 695 nxr2_x1
xsubckt_3139_nor3_x0 1 0 4829 4831 4834 4880 nor3_x0
xsubckt_1089_oa22_x2 0 6734 1 1737 6743 6735 oa22_x2
xsubckt_1406_a2_x2 0 6434 1 205 1739 a2_x2
xsubckt_1446_a2_x2 0 6395 1 181 210 a2_x2
xsubckt_2293_nxr2_x1 5659 1 0 43 42 nxr2_x1
xsubckt_2346_oa22_x2 0 5608 1 7790 7192 7695 oa22_x2
xsubckt_9686_sff1_x4 1 1872 0 8790 801 sff1_x4
xsubckt_8790_sff1_x4 1 1872 0 9603 1779 sff1_x4
xsubckt_8712_sff1_x4 1 1872 0 9681 1114 sff1_x4
xsubckt_7549_nor2_x0 1 0 7954 531 536 nor2_x0
xsubckt_6754_a2_x2 0 8540 1 7134 7230 a2_x2
xsubckt_6642_oa22_x2 0 2005 1 7456 7625 7631 oa22_x2
xsubckt_6478_mx2_x2 0 2166 1 712 1086 1054 mx2_x2
xsubckt_5943_mx2_x2 0 2689 1 712 1196 1164 mx2_x2
xsubckt_5941_mx2_x2 0 2691 1 710 2692 2693 mx2_x2
xsubckt_5797_a3_x2 1 2828 0 40 7790 7791 a3_x2
xsubckt_5639_nand4_x0 1 0 2942 2951 1821 1822 1823 nand4_x0
xsubckt_4682_a2_x2 0 9627 1 3730 3732 a2_x2
xsubckt_4410_mx3_x2 1 0 9852 3779 3897 1510 3859 3860 mx3_x2
xsubckt_3353_ao22_x2 0 4619 1 7481 705 707 ao22_x2
xsubckt_3182_nand2_x0 1 0 4786 7153 7274 nand2_x0
xsubckt_2902_ao22_x2 0 5061 1 5068 7215 704 ao22_x2
xsubckt_2476_nand3_x0 1 0 5479 6930 7108 7152 nand3_x0
xsubckt_955_xr2_x1 6863 0 1 671 46 xr2_x1
xsubckt_736_nand2_x0 1 0 7068 529 1741 nand2_x0
xsubckt_1450_xr2_x1 6391 0 1 181 210 xr2_x1
xsubckt_1661_a2_x2 0 6180 1 7227 216 a2_x2
xsubckt_1681_a2_x2 0 6160 1 7232 211 a2_x2
xsubckt_1803_oa22_x2 0 6046 1 6056 6298 6300 oa22_x2
xsubckt_2212_nand2_x0 1 0 5739 5741 709 nand2_x0
xsubckt_2390_nand2_x0 1 0 5564 5565 5568 nand2_x0
xsubckt_9608_sff1_x4 1 1872 0 8865 846 sff1_x4
xsubckt_9520_sff1_x4 1 1872 0 8946 957 sff1_x4
xsubckt_9163_sff1_x4 1 1872 0 9295 586 sff1_x4
xsubckt_8786_sff1_x4 1 1872 0 9607 1783 sff1_x4
xsubckt_7538_oa22_x2 0 7963 1 7970 7093 7210 oa22_x2
xsubckt_7292_ao22_x2 0 8103 1 645 7680 595 ao22_x2
xsubckt_6786_nand2_x0 1 0 8508 8533 7613 nand2_x0
xsubckt_6038_o2_x2 0 2596 1 1642 710 o2_x2
xsubckt_5994_nand2_x0 1 0 2639 2640 2643 nand2_x0
xsubckt_5816_nand2_x0 1 0 2810 2811 7620 nand2_x0
xsubckt_5307_oa22_x2 0 3210 1 7690 3211 7680 oa22_x2
xsubckt_4416_mx3_x2 1 0 9846 3779 3896 1504 3841 3843 mx3_x2
xsubckt_4414_mx3_x2 1 0 9848 3779 3896 1506 3847 3849 mx3_x2
xsubckt_4412_mx3_x2 1 0 9850 3779 3896 1508 3853 3855 mx3_x2
xsubckt_3178_nand3_x0 1 0 4790 4791 4792 7216 nand3_x0
xsubckt_2724_o3_x2 0 5236 1 5237 5246 704 o3_x2
xsubckt_2032_nand2_x0 1 0 5837 5838 6156 nand2_x0
xsubckt_9594_sff1_x4 1 1872 0 8879 921 sff1_x4
xsubckt_9159_sff1_x4 1 1872 0 9299 596 sff1_x4
xsubckt_9071_sff1_x4 1 1872 0 9355 1306 sff1_x4
xsubckt_8708_sff1_x4 1 1872 0 9685 1119 sff1_x4
xsubckt_8620_sff1_x4 1 1872 0 9773 1462 sff1_x4
xsubckt_6638_oa22_x2 0 2009 1 7631 2014 711 oa22_x2
xsubckt_4830_nand4_x0 1 0 3612 3622 1774 1772 1771 nand4_x0
xsubckt_4418_mx3_x2 1 0 9844 3779 3896 1502 3835 3837 mx3_x2
xsubckt_4372_mx3_x2 1 0 9887 3782 3897 971 3871 3872 mx3_x2
xsubckt_3261_ao22_x2 0 4709 1 704 4711 703 ao22_x2
xsubckt_1150_nand2_x0 1 0 6677 692 67 nand2_x0
xsubckt_1060_nand2_x0 1 0 6762 587 1767 nand2_x0
xsubckt_942_oa22_x2 0 6875 1 525 6899 6876 oa22_x2
xsubckt_9516_sff1_x4 1 1872 0 8950 961 sff1_x4
xsubckt_8694_sff1_x4 1 1872 0 9699 1105 sff1_x4
xsubckt_6428_nand2_x0 1 0 2214 2215 2217 nand2_x0
xsubckt_5937_ao22_x2 0 9407 1 2695 2697 2730 ao22_x2
xsubckt_4378_mx3_x2 1 0 9881 3782 3896 995 3850 3852 mx3_x2
xsubckt_4376_mx3_x2 1 0 9883 3782 3897 997 3856 3857 mx3_x2
xsubckt_4374_mx3_x2 1 0 9885 3782 3897 969 3863 3864 mx3_x2
xsubckt_4100_xr2_x1 3888 0 1 65 54 xr2_x1
xsubckt_3872_nand2_x0 1 0 4109 210 682 nand2_x0
xsubckt_811_nxr2_x1 7000 1 0 690 65 nxr2_x1
xsubckt_645_a4_x2 0 7150 1 7151 7153 7156 7157 a4_x2
xsubckt_1262_oa22_x2 0 6570 1 6719 6579 6571 oa22_x2
xsubckt_1299_o2_x2 0 6535 1 6536 6537 o2_x2
xsubckt_1767_nand2_x0 1 0 6078 6114 6264 nand2_x0
xsubckt_9067_sff1_x4 1 1872 0 9359 1311 sff1_x4
xsubckt_8616_sff1_x4 1 1872 0 9777 1466 sff1_x4
xsubckt_7802_mx3_x2 1 0 9035 7826 3896 1363 3805 3807 mx3_x2
xsubckt_7800_mx3_x2 1 0 9037 7826 3896 1365 3811 3813 mx3_x2
xsubckt_6248_nand2_x0 1 0 2390 2391 2393 nand2_x0
xsubckt_6023_oa22_x2 0 2610 1 2729 2613 2611 oa22_x2
xsubckt_3843_mx3_x2 1 0 4137 707 705 4138 1589 725 mx3_x2
xsubckt_3321_mx2_x2 0 4650 1 705 1503 1343 mx2_x2
xsubckt_2872_o2_x2 0 5091 1 705 905 o2_x2
xsubckt_9424_sff1_x4 1 1872 0 9042 1370 sff1_x4
xsubckt_7804_mx3_x2 1 0 9033 7826 3896 1360 3799 3801 mx3_x2
xsubckt_7760_mx3_x2 1 0 9107 7828 3896 1051 3829 3831 mx3_x2
xsubckt_7354_oa22_x2 0 9281 1 8076 8057 8058 oa22_x2
xsubckt_7218_inv_x0 1 0 8156 9093 inv_x0
xsubckt_6158_nand2_x0 1 0 2479 2480 712 nand2_x0
xsubckt_5276_nand2_x0 1 0 3239 3487 7672 nand2_x0
xsubckt_3849_mx3_x2 1 0 4131 707 705 4132 1045 1173 mx3_x2
xsubckt_3718_mx2_x2 0 4260 1 705 1207 1079 mx2_x2
xsubckt_3716_mx2_x2 0 4262 1 705 1143 983 mx2_x2
xsubckt_3325_mx2_x2 0 4646 1 7219 4647 4648 mx2_x2
xsubckt_3323_mx2_x2 0 4648 1 705 1727 895 mx2_x2
xsubckt_3063_mx3_x2 1 0 4903 707 705 4904 1316 1476 mx3_x2
xsubckt_753_a3_x2 1 7054 0 7112 7120 1737 a3_x2
xsubckt_733_a3_x2 1 7070 0 7673 7675 1741 a3_x2
xsubckt_1483_nand4_x0 1 0 6358 6360 6365 6371 6376 nand4_x0
xsubckt_1840_nand2_x0 1 0 6012 6116 6235 nand2_x0
xsubckt_9498_sff1_x4 1 1872 0 8968 1170 sff1_x4
xsubckt_8598_sff1_x4 1 1872 0 9795 1457 sff1_x4
xsubckt_8524_sff1_x4 1 1872 0 9869 982 sff1_x4
xsubckt_7766_mx3_x2 1 0 9101 7828 3896 1045 3811 3813 mx3_x2
xsubckt_7764_mx3_x2 1 0 9103 7828 3896 1047 3817 3819 mx3_x2
xsubckt_7762_mx3_x2 1 0 9105 7828 3896 1049 3823 3825 mx3_x2
xsubckt_7467_nand3_x0 1 0 7993 7994 2858 7201 nand3_x0
xsubckt_7240_mx2_x2 0 9308 1 5752 8141 600 mx2_x2
xsubckt_4733_nand3_x0 1 0 3687 3688 3701 1799 nand3_x0
xsubckt_130_inv_x0 1 0 371 7661 inv_x0
xsubckt_521_inv_x0 1 0 1827 7270 inv_x0
xsubckt_523_inv_x0 1 0 220 7268 inv_x0
xsubckt_1229_nand2_x0 1 0 6602 687 62 nand2_x0
xsubckt_2066_oa22_x2 0 5806 1 5807 5808 6110 oa22_x2
xsubckt_2401_mx2_x2 0 5553 1 705 1032 840 mx2_x2
xsubckt_9855_sff1_x4 1 1872 0 8621 1239 sff1_x4
xsubckt_9332_sff1_x4 1 1872 0 9129 1328 sff1_x4
xsubckt_8955_sff1_x4 1 1872 0 141 78 sff1_x4
xsubckt_8432_sff1_x4 1 1872 0 9961 882 sff1_x4
xsubckt_7982_mx2_x2 0 8869 1 7811 3894 872 mx2_x2
xsubckt_7768_mx3_x2 1 0 9099 7828 3896 1043 3805 3807 mx3_x2
xsubckt_5525_nand3_x0 1 0 3025 3031 1855 1856 nand3_x0
xsubckt_5066_nxr2_x1 3432 1 0 3538 3541 nxr2_x1
xsubckt_5031_oa22_x2 0 9546 1 7168 3462 3464 oa22_x2
xsubckt_4729_nand4_x0 1 0 3690 3699 1799 1798 1797 nand4_x0
xsubckt_4109_a4_x2 0 3881 1 65 54 51 50 a4_x2
xsubckt_3765_nor2_x0 1 0 4214 212 684 nor2_x0
xsubckt_3715_nxr2_x1 4263 1 0 4265 4266 nxr2_x1
xsubckt_3522_ao22_x2 0 4453 1 4454 4457 7219 ao22_x2
xsubckt_2865_nor2_x0 1 0 5098 5099 5101 nor2_x0
xsubckt_754_oa22_x2 0 10099 1 7118 7076 7054 oa22_x2
xsubckt_596_ao22_x2 0 7195 1 7196 7202 7205 ao22_x2
xsubckt_136_inv_x0 1 0 660 7655 inv_x0
xsubckt_134_inv_x0 1 0 669 7657 inv_x0
xsubckt_132_inv_x0 1 0 372 7659 inv_x0
xsubckt_525_inv_x0 1 0 217 7266 inv_x0
xsubckt_527_inv_x0 1 0 215 7264 inv_x0
xsubckt_529_inv_x0 1 0 213 7262 inv_x0
xsubckt_1888_ao22_x2 0 5969 1 5970 5978 6327 ao22_x2
xsubckt_2149_mx3_x2 1 0 456 7162 5754 207 85 117 mx3_x2
xsubckt_2403_mx2_x2 0 5551 1 705 936 808 mx2_x2
xsubckt_9763_sff1_x4 1 1872 0 8713 1715 sff1_x4
xsubckt_9328_sff1_x4 1 1872 0 9133 1333 sff1_x4
xsubckt_7986_mx2_x2 0 8865 1 7811 3882 846 mx2_x2
xsubckt_7984_mx2_x2 0 8867 1 7811 3890 860 mx2_x2
xsubckt_7626_nor2_x0 1 0 7893 7894 7895 nor2_x0
xsubckt_6848_nand2_x0 1 0 8447 8448 8450 nand2_x0
xsubckt_6842_mx3_x2 1 0 8453 708 7631 8454 8456 8457 mx3_x2
xsubckt_6807_oa22_x2 0 8488 1 7625 1686 8489 oa22_x2
xsubckt_6713_mx2_x2 0 8580 1 710 1432 1272 mx2_x2
xsubckt_6362_oa22_x2 0 2279 1 1281 710 712 oa22_x2
xsubckt_6322_mx2_x2 0 2318 1 712 2319 2320 mx2_x2
xsubckt_6320_mx2_x2 0 2320 1 710 1474 1314 mx2_x2
xsubckt_6126_ao22_x2 0 2510 1 709 2511 708 ao22_x2
xsubckt_6062_mx3_x2 1 0 2572 7628 7613 2573 2579 2581 mx3_x2
xsubckt_6060_mx3_x2 1 0 2574 712 710 2575 778 906 mx3_x2
xsubckt_5985_oa22_x2 0 2648 1 7625 1675 2649 oa22_x2
xsubckt_5027_oa22_x2 0 9547 1 7168 3465 3467 oa22_x2
xsubckt_2754_mx2_x2 0 10079 1 5593 5207 202 mx2_x2
xsubckt_1010_a2_x2 0 6810 1 6811 6878 a2_x2
xsubckt_940_mx2_x2 0 6877 1 7685 7048 379 mx2_x2
xsubckt_708_nand2_x0 1 0 7093 7789 1740 nand2_x0
xsubckt_618_nand2_x0 1 0 7173 7174 7191 nand2_x0
xsubckt_138_inv_x0 1 0 663 7653 inv_x0
xsubckt_481_inv_x0 1 0 1886 7310 inv_x0
xsubckt_483_inv_x0 1 0 1885 7308 inv_x0
xsubckt_485_inv_x0 1 0 1884 7306 inv_x0
xsubckt_1470_nxr2_x1 6371 1 0 186 215 nxr2_x1
xsubckt_2342_nor2_x0 1 0 5611 5612 529 nor2_x0
xsubckt_2419_oa22_x2 0 5535 1 7152 5536 5537 oa22_x2
xsubckt_9240_sff1_x4 1 1872 0 9221 339 sff1_x4
xsubckt_8863_sff1_x4 1 1872 0 9530 135 sff1_x4
xsubckt_8428_sff1_x4 1 1872 0 9965 886 sff1_x4
xsubckt_8340_sff1_x4 1 1872 0 10045 1577 sff1_x4
xsubckt_7988_mx2_x2 0 8863 1 7811 3874 844 mx2_x2
xsubckt_7981_nand2_x0 1 0 7811 3793 3900 nand2_x0
xsubckt_6793_oa22_x2 0 8501 1 7631 8502 7628 oa22_x2
xsubckt_6328_mx2_x2 0 2312 1 710 1026 834 mx2_x2
xsubckt_6326_mx2_x2 0 2314 1 710 1442 1282 mx2_x2
xsubckt_5782_a4_x2 0 2841 1 7064 7675 7676 1741 a4_x2
xsubckt_5615_a3_x2 1 9464 0 2960 2961 40 a3_x2
xsubckt_4761_ao22_x2 0 3665 1 1789 3667 40 ao22_x2
xsubckt_4706_a3_x2 1 3709 0 1773 1762 1746 a3_x2
xsubckt_3563_a3_x2 1 4412 0 4413 4417 703 a3_x2
xsubckt_3198_nor3_x0 1 0 4771 4772 4773 4774 nor3_x0
xsubckt_2854_oa22_x2 0 5108 1 5595 5608 200 oa22_x2
xsubckt_2530_ao22_x2 0 5426 1 5427 5432 706 ao22_x2
xcmpt_zero_0 1 0 643 zero_x1
xcmpt_zero_1 1 0 642 zero_x1
xcmpt_zero_2 1 0 631 zero_x1
xcmpt_zero_3 1 0 620 zero_x1
xcmpt_zero_4 1 0 617 zero_x1
xcmpt_zero_5 1 0 616 zero_x1
xcmpt_zero_6 1 0 615 zero_x1
xcmpt_zero_7 1 0 614 zero_x1
xcmpt_zero_8 1 0 613 zero_x1
xcmpt_zero_9 1 0 612 zero_x1
xsubckt_487_inv_x0 1 0 1883 7304 inv_x0
xsubckt_489_inv_x0 1 0 1882 7302 inv_x0
xsubckt_1304_a2_x2 0 6531 1 683 58 a2_x2
xsubckt_2092_nand2_x0 1 0 5786 434 308 nand2_x0
xsubckt_9759_sff1_x4 1 1872 0 8717 1719 sff1_x4
xsubckt_9671_sff1_x4 1 1872 0 8805 808 sff1_x4
xsubckt_9236_sff1_x4 1 1872 0 9225 313 sff1_x4
xsubckt_8255_a2_x2 0 7793 1 7794 7795 a2_x2
xsubckt_6671_mx2_x2 0 1977 1 710 1689 1561 mx2_x2
xsubckt_6612_a2_x2 0 9392 1 2035 2075 a2_x2
xsubckt_6284_mx2_x2 0 2355 1 710 1027 835 mx2_x2
xsubckt_6282_mx2_x2 0 2357 1 710 1443 1283 mx2_x2
xsubckt_5893_oa22_x2 0 9410 1 5703 2786 2736 oa22_x2
xsubckt_2964_xr2_x1 5001 0 1 227 699 xr2_x1
xsubckt_2799_nand2_x0 1 0 5162 5163 5586 nand2_x0
xsubckt_1296_nand3_x0 1 0 6538 6539 6540 6541 nand3_x0
xsubckt_1920_a3_x2 1 5940 0 5951 6338 6357 a3_x2
xsubckt_2431_nand3_x0 1 0 5524 5525 5527 7218 nand3_x0
xsubckt_8859_sff1_x4 1 1872 0 9534 109 sff1_x4
xsubckt_8771_sff1_x4 1 1872 0 9622 1800 sff1_x4
xsubckt_8336_sff1_x4 1 1872 0 10049 1581 sff1_x4
xsubckt_7000_o2_x2 0 8299 1 8300 709 o2_x2
xsubckt_6477_a2_x2 0 2167 1 2168 7625 a2_x2
xsubckt_6286_mx2_x2 0 2353 1 708 2354 2356 mx2_x2
xsubckt_5751_mx2_x2 0 9432 1 2856 471 508 mx2_x2
xsubckt_4886_nor3_x0 1 0 3569 3572 3631 7720 nor3_x0
xsubckt_4821_o4_x2 0 3619 1 3627 3631 7712 7713 o4_x2
xsubckt_4786_a3_x2 1 3646 0 1785 1783 1782 a3_x2
xsubckt_4757_ao22_x2 0 3668 1 1790 3669 40 ao22_x2
xsubckt_4015_nand3_x0 1 0 3968 3969 4121 7104 nand3_x0
xsubckt_3754_nand2_x0 1 0 4224 7152 7258 nand2_x0
xsubckt_2961_ao22_x2 0 10075 1 5004 5043 5050 ao22_x2
xsubckt_1054_mx2_x2 0 6768 1 7685 6939 7678 mx2_x2
xsubckt_1181_ao22_x2 0 6647 1 6648 6652 7038 ao22_x2
xsubckt_1306_xr2_x1 6529 0 1 683 58 xr2_x1
xsubckt_1618_a2_x2 0 6223 1 195 225 a2_x2
xsubckt_1658_a2_x2 0 6183 1 6185 6189 a2_x2
xsubckt_1902_nand2_x0 1 0 5956 6116 6354 nand2_x0
xsubckt_9667_sff1_x4 1 1872 0 8809 819 sff1_x4
xsubckt_9144_sff1_x4 1 1872 0 9314 1139 sff1_x4
xsubckt_7443_nand2_x0 1 0 8008 8077 8127 nand2_x0
xsubckt_7074_oa22_x2 0 8227 1 40 1741 177 oa22_x2
xsubckt_6651_nand2_x0 1 0 1996 1997 7631 nand2_x0
xsubckt_6131_o2_x2 0 2505 1 2506 709 o2_x2
xsubckt_5757_mx2_x2 0 9426 1 2856 464 501 mx2_x2
xsubckt_5755_mx2_x2 0 9428 1 2856 466 503 mx2_x2
xsubckt_5753_mx2_x2 0 9430 1 2856 469 506 mx2_x2
xsubckt_4615_mx3_x2 1 0 9661 3765 3897 1257 3863 3864 mx3_x2
xsubckt_4613_mx3_x2 1 0 9663 3765 3897 1259 3871 3872 mx3_x2
xsubckt_4220_mx3_x2 1 0 10023 3899 3896 1583 3797 3798 mx3_x2
xsubckt_934_nor2_x0 1 0 6883 6884 7791 nor2_x0
xsubckt_1812_nand2_x0 1 0 1906 6038 6042 nand2_x0
xsubckt_2201_o2_x2 0 5749 1 5750 5752 o2_x2
xsubckt_9501_sff1_x4 1 1872 0 8965 968 sff1_x4
xsubckt_8767_sff1_x4 1 1872 0 9626 1804 sff1_x4
xsubckt_7630_ao22_x2 0 7890 1 607 594 371 ao22_x2
xsubckt_7374_o2_x2 0 9275 1 8043 8045 o2_x2
xsubckt_5759_mx2_x2 0 9424 1 2856 462 499 mx2_x2
xsubckt_4823_oa22_x2 0 3618 1 3622 1774 1772 oa22_x2
xsubckt_4619_mx3_x2 1 0 9657 3765 3896 1283 3850 3852 mx3_x2
xsubckt_4617_mx3_x2 1 0 9659 3765 3897 1285 3856 3857 mx3_x2
xsubckt_4440_mx2_x2 0 9824 1 3776 3874 1004 mx2_x2
xsubckt_3424_o2_x2 0 4549 1 4550 7218 o2_x2
xsubckt_2535_o2_x2 0 5421 1 218 690 o2_x2
xsubckt_2514_nand2_x0 1 0 5442 7217 1404 nand2_x0
xsubckt_50_inv_x0 1 0 62 7741 inv_x0
xsubckt_52_inv_x0 1 0 64 7739 inv_x0
xsubckt_1268_xr2_x1 6565 0 1 685 60 xr2_x1
xsubckt_1770_oa22_x2 0 1910 1 6111 6080 6076 oa22_x2
xsubckt_1858_oa22_x2 0 5996 1 6318 6007 5997 oa22_x2
xsubckt_9575_sff1_x4 1 1872 0 8898 913 sff1_x4
xsubckt_9052_sff1_x4 1 1872 0 9374 1308 sff1_x4
xsubckt_8675_sff1_x4 1 1872 0 9718 1440 sff1_x4
xsubckt_8601_sff1_x4 1 1872 0 9792 1452 sff1_x4
xsubckt_8143_mx3_x2 1 0 8684 7804 3896 1686 3814 3816 mx3_x2
xsubckt_8141_mx3_x2 1 0 8686 7804 3896 1688 3820 3822 mx3_x2
xsubckt_7269_ao22_x2 0 8118 1 7131 7195 599 ao22_x2
xsubckt_7263_nand2_x0 1 0 8122 8138 602 nand2_x0
xsubckt_7173_nand2_x0 1 0 8164 8165 7182 nand2_x0
xsubckt_5274_oa22_x2 0 3241 1 3247 3248 3249 oa22_x2
xsubckt_5193_nor2_x0 1 0 3315 3316 3317 nor2_x0
xsubckt_4579_mx3_x2 1 0 9694 3768 3897 1098 3867 3868 mx3_x2
xsubckt_3909_nand4_x0 1 0 4072 5604 532 7689 57 nand4_x0
xsubckt_3394_nand2_x0 1 0 4578 7153 7269 nand2_x0
xsubckt_2920_nor3_x0 1 0 5044 5046 5049 5101 nor3_x0
xsubckt_870_nxr2_x1 6944 1 0 675 50 nxr2_x1
xsubckt_58_inv_x0 1 0 72 7733 inv_x0
xsubckt_56_inv_x0 1 0 70 7735 inv_x0
xsubckt_54_inv_x0 1 0 67 7737 inv_x0
xsubckt_1199_nand2_x0 1 0 6630 588 1794 nand2_x0
xsubckt_1392_o2_x2 0 6447 1 6448 6449 o2_x2
xsubckt_1542_nand2_x0 1 0 6299 417 201 nand2_x0
xsubckt_9048_sff1_x4 1 1872 0 9378 526 sff1_x4
xsubckt_8149_mx3_x2 1 0 8678 7804 3896 1679 3797 3798 mx3_x2
xsubckt_8147_mx3_x2 1 0 8680 7804 3896 1682 3802 3804 mx3_x2
xsubckt_8145_mx3_x2 1 0 8682 7804 3896 1684 3808 3810 mx3_x2
xsubckt_8016_mx2_x2 0 8837 1 7809 3894 840 mx2_x2
xsubckt_6004_oa22_x2 0 2629 1 1259 710 712 oa22_x2
xsubckt_5918_ao22_x2 0 2713 1 2714 2722 711 ao22_x2
xsubckt_5182_oa22_x2 0 3325 1 7087 3326 3328 oa22_x2
xsubckt_4059_mx2_x2 0 3925 1 705 1136 976 mx2_x2
xsubckt_4055_mx2_x2 0 3929 1 705 1200 1072 mx2_x2
xsubckt_3997_oa22_x2 0 3986 1 3987 705 707 oa22_x2
xsubckt_3993_o2_x2 0 3990 1 3991 704 o2_x2
xsubckt_2869_o2_x2 0 5094 1 705 1001 o2_x2
xsubckt_2851_nand3_x0 1 0 5111 5112 5114 5115 nand3_x0
xsubckt_1007_ao22_x2 0 6813 1 6836 6816 6814 ao22_x2
xsubckt_831_oa22_x2 0 6981 1 7014 7001 7003 oa22_x2
xsubckt_768_nand2_x0 1 0 413 7041 7126 nand2_x0
xsubckt_1243_oa22_x2 0 6588 1 6719 6597 6589 oa22_x2
xsubckt_9840_sff1_x4 1 1872 0 8636 1225 sff1_x4
xsubckt_9483_sff1_x4 1 1872 0 8983 1186 sff1_x4
xsubckt_9405_sff1_x4 1 1872 0 9061 1372 sff1_x4
xsubckt_8583_sff1_x4 1 1872 0 9810 1019 sff1_x4
xsubckt_8018_mx2_x2 0 8835 1 7809 3890 828 mx2_x2
xsubckt_7335_oa22_x2 0 8071 1 7679 644 7694 oa22_x2
xsubckt_6540_nand3_x0 1 0 2105 2106 2109 7620 nand3_x0
xsubckt_5848_nand2_x0 1 0 2779 7604 710 nand2_x0
xsubckt_5051_nand2_x0 1 0 9542 3446 3452 nand2_x0
xsubckt_3524_mx2_x2 0 4451 1 705 1690 1562 mx2_x2
xsubckt_2051_oa22_x2 0 5820 1 5829 6409 6412 oa22_x2
xsubckt_9479_sff1_x4 1 1872 0 8987 1190 sff1_x4
xsubckt_9391_sff1_x4 1 1872 0 9070 359 sff1_x4
xsubckt_8940_sff1_x4 1 1872 0 9453 1817 sff1_x4
xsubckt_8505_sff1_x4 1 1872 0 9888 972 sff1_x4
xsubckt_7965_mx3_x2 1 0 8884 7814 3896 927 3838 3840 mx3_x2
xsubckt_7963_mx3_x2 1 0 8886 7814 3896 929 3844 3846 mx3_x2
xsubckt_7961_mx3_x2 1 0 8888 7814 3896 931 3850 3852 mx3_x2
xsubckt_6803_nand2_x0 1 0 8492 1654 7625 nand2_x0
xsubckt_3875_mx2_x2 0 4106 1 705 916 788 mx2_x2
xsubckt_3482_mx2_x2 0 4492 1 706 4493 4495 mx2_x2
xsubckt_3480_mx2_x2 0 4494 1 705 1211 1083 mx2_x2
xsubckt_3091_mx2_x2 0 4876 1 7217 7507 7511 mx2_x2
xsubckt_1092_nand2_x0 1 0 6732 695 70 nand2_x0
xsubckt_1004_nand2_x0 1 0 6816 6817 6842 nand2_x0
xsubckt_841_nand2_x0 1 0 6971 587 1778 nand2_x0
xsubckt_818_a2_x2 0 6993 1 6994 6995 a2_x2
xsubckt_331_inv_x0 1 0 1499 7460 inv_x0
xsubckt_1611_nand3_x0 1 0 6230 6234 7240 228 nand3_x0
xsubckt_9836_sff1_x4 1 1872 0 8640 1229 sff1_x4
xsubckt_9313_sff1_x4 1 1872 0 9148 1349 sff1_x4
xsubckt_8579_sff1_x4 1 1872 0 9814 1024 sff1_x4
xsubckt_8491_sff1_x4 1 1872 0 9902 1527 sff1_x4
xsubckt_7969_mx3_x2 1 0 8880 7814 3896 922 3826 3828 mx3_x2
xsubckt_7967_mx3_x2 1 0 8882 7814 3896 925 3832 3834 mx3_x2
xsubckt_7773_nand2_x0 1 0 7825 3900 3904 nand2_x0
xsubckt_7238_nand4_x0 1 0 8142 9092 9093 9095 9094 nand4_x0
xsubckt_5977_nor2_x0 1 0 2655 2656 7134 nor2_x0
xsubckt_5004_a3_x2 1 3482 0 40 62 7780 a3_x2
xsubckt_3879_mx2_x2 0 4102 1 705 1684 1556 mx2_x2
xsubckt_3877_mx2_x2 0 4104 1 707 4105 4106 mx2_x2
xsubckt_3343_xr2_x1 4629 0 1 220 692 xr2_x1
xsubckt_3097_mx2_x2 0 4870 1 706 4871 4874 mx2_x2
xsubckt_3095_mx2_x2 0 4872 1 7217 7510 7514 mx2_x2
xsubckt_3093_mx2_x2 0 4874 1 707 4875 4876 mx2_x2
xsubckt_878_a2_x2 0 6936 1 7143 1826 a2_x2
xsubckt_858_a2_x2 0 6955 1 204 1739 a2_x2
xsubckt_838_a2_x2 0 6974 1 7143 1848 a2_x2
xsubckt_735_oa22_x2 0 10102 1 7677 7069 7077 oa22_x2
xsubckt_333_inv_x0 1 0 1339 7458 inv_x0
xsubckt_335_inv_x0 1 0 922 7456 inv_x0
xsubckt_337_inv_x0 1 0 826 7454 inv_x0
xsubckt_2213_mx2_x2 0 5738 1 710 1436 1276 mx2_x2
xsubckt_2215_mx2_x2 0 5736 1 710 1404 1244 mx2_x2
xsubckt_9387_sff1_x4 1 1872 0 9074 363 sff1_x4
xsubckt_8936_sff1_x4 1 1872 0 9457 1821 sff1_x4
xsubckt_8413_sff1_x4 1 1872 0 9980 902 sff1_x4
xsubckt_7283_a4_x2 0 8108 1 8136 533 7679 644 a4_x2
xsubckt_7056_mx2_x2 0 8244 1 710 1008 816 mx2_x2
xsubckt_6343_oa22_x2 0 2298 1 7625 1697 2299 oa22_x2
xsubckt_5660_a4_x2 0 2927 1 2935 1814 1816 1817 a4_x2
xsubckt_5474_nand4_x0 1 0 3062 3071 1808 1809 1810 nand4_x0
xsubckt_5210_nand3_x0 1 0 3300 40 133 7780 nand3_x0
xsubckt_5024_a3_x2 1 3467 0 40 57 7780 a3_x2
xsubckt_4075_nand3_x0 1 0 3909 3910 5595 5608 nand3_x0
xsubckt_3099_mx2_x2 0 4868 1 7217 7502 7504 mx2_x2
xsubckt_3015_nand3_x0 1 0 4950 4951 5113 7104 nand3_x0
xsubckt_2951_mx2_x2 0 5013 1 7215 5014 5019 mx2_x2
xsubckt_2812_xr2_x1 5150 0 1 200 672 xr2_x1
xsubckt_2608_mx2_x2 0 5350 1 705 1134 974 mx2_x2
xsubckt_1094_nxr2_x1 6730 1 0 695 70 nxr2_x1
xsubckt_661_nand2_x0 1 0 7134 1741 40 nand2_x0
xsubckt_291_inv_x0 1 0 1602 7500 inv_x0
xsubckt_293_inv_x0 1 0 1250 7498 inv_x0
xsubckt_339_inv_x0 1 0 1594 7452 inv_x0
xsubckt_1346_ao22_x2 0 6491 1 6514 6511 6512 ao22_x2
xsubckt_1451_nxr2_x1 6390 1 0 181 210 nxr2_x1
xsubckt_1710_a4_x2 0 6131 1 6205 6220 6317 6325 a4_x2
xsubckt_1730_a4_x2 0 6111 1 6113 6115 6117 7214 a4_x2
xsubckt_1962_nand2_x0 1 0 5901 6116 6372 nand2_x0
xsubckt_9744_sff1_x4 1 1872 0 8732 1705 sff1_x4
xsubckt_9309_sff1_x4 1 1872 0 9152 1323 sff1_x4
xsubckt_9221_sff1_x4 1 1872 0 300 528 sff1_x4
xsubckt_8487_sff1_x4 1 1872 0 9906 1531 sff1_x4
xsubckt_8409_sff1_x4 1 1872 0 9984 876 sff1_x4
xsubckt_8117_nand2_x0 1 0 7803 3790 3796 nand2_x0
xsubckt_6870_mx2_x2 0 8426 1 710 1493 1333 mx2_x2
xsubckt_6700_oa22_x2 0 1948 1 1949 1962 2728 oa22_x2
xsubckt_6527_mx2_x2 0 2118 1 710 1021 829 mx2_x2
xsubckt_6525_mx2_x2 0 2120 1 710 1501 1341 mx2_x2
xsubckt_6132_mx2_x2 0 2504 1 710 1702 1574 mx2_x2
xsubckt_6130_mx2_x2 0 2506 1 712 2507 2508 mx2_x2
xsubckt_6090_nand3_x0 1 0 2545 2546 2549 7620 nand3_x0
xsubckt_5513_a3_x2 1 3034 0 3039 1858 1860 a3_x2
xsubckt_4791_a4_x2 0 3642 1 3646 3657 1786 1781 a4_x2
xsubckt_4771_a4_x2 0 3658 1 1790 1789 1788 1787 a4_x2
xsubckt_3546_nand2_x0 1 0 4429 4430 4433 nand2_x0
xsubckt_3442_nand4_x0 1 0 4531 5604 532 7689 66 nand4_x0
xsubckt_3286_a3_x2 1 4684 0 4685 4687 4688 a3_x2
xsubckt_3247_nxr2_x1 4723 1 0 222 694 nxr2_x1
xsubckt_2568_mx2_x2 0 5389 1 705 913 785 mx2_x2
xsubckt_2566_mx2_x2 0 5391 1 705 1649 1521 mx2_x2
xsubckt_1161_nand3_x0 1 0 6666 6667 6668 6669 nand3_x0
xsubckt_295_inv_x0 1 0 1249 7496 inv_x0
xsubckt_297_inv_x0 1 0 1600 7494 inv_x0
xsubckt_299_inv_x0 1 0 926 7492 inv_x0
xsubckt_1222_a2_x2 0 6608 1 216 1739 a2_x2
xsubckt_1423_nor2_x0 1 0 6418 180 209 nor2_x0
xsubckt_1604_nand2_x0 1 0 6237 197 227 nand2_x0
xsubckt_1782_nand2_x0 1 0 1909 6065 6069 nand2_x0
xsubckt_1872_nand2_x0 1 0 5983 6116 6206 nand2_x0
xsubckt_1958_nand3_x0 1 0 5905 5906 6369 7788 nand3_x0
xsubckt_9295_sff1_x4 1 1872 0 9166 673 sff1_x4
xsubckt_8844_sff1_x4 1 1872 0 9549 59 sff1_x4
xsubckt_8321_sff1_x4 1 1872 0 10064 216 sff1_x4
xsubckt_6538_ao22_x2 0 2107 1 711 2119 708 ao22_x2
xsubckt_6483_mx2_x2 0 2161 1 710 766 1630 mx2_x2
xsubckt_6481_mx2_x2 0 2163 1 710 1694 1566 mx2_x2
xsubckt_6138_mx2_x2 0 2498 1 710 742 1606 mx2_x2
xsubckt_5593_a3_x2 1 9470 0 2976 2977 40 a3_x2
xsubckt_5446_a2_x2 0 9510 1 3083 3084 a2_x2
xsubckt_4845_nor4_x0 1 0 3601 3605 3631 7714 7715 nor4_x0
xsubckt_4088_a2_x2 0 3897 1 517 7785 a2_x2
xsubckt_4020_oa22_x2 0 3963 1 7179 4003 3964 oa22_x2
xsubckt_3910_a3_x2 1 4071 0 4072 4073 4075 a3_x2
xsubckt_3643_oa22_x2 0 4334 1 5595 5608 214 oa22_x2
xsubckt_3366_nand2_x0 1 0 4606 4607 4610 nand2_x0
xsubckt_2484_nand2_x0 1 0 5472 5473 5474 nand2_x0
xsubckt_1087_a2_x2 0 6736 1 224 1739 a2_x2
xsubckt_2179_mx2_x2 0 9080 1 7199 402 370 mx2_x2
xsubckt_2205_nor3_x0 1 0 5746 648 647 646 nor3_x0
xsubckt_9652_sff1_x4 1 1872 0 8824 835 sff1_x4
xsubckt_9217_sff1_x4 1 1872 0 9242 529 sff1_x4
xsubckt_8752_sff1_x4 1 1872 0 9641 1266 sff1_x4
xsubckt_8395_sff1_x4 1 1872 0 10095 712 sff1_x4
xsubckt_8317_sff1_x4 1 1872 0 10068 221 sff1_x4
xsubckt_8268_buf_x1 1 0 1736 8741 buf_x1
xsubckt_7662_nand3_x0 1 0 7863 7865 7679 644 nand3_x0
xsubckt_6629_a2_x2 0 2018 1 2019 2025 a2_x2
xsubckt_6570_a2_x2 0 9393 1 2076 2126 a2_x2
xsubckt_6485_mx2_x2 0 2159 1 711 2160 2162 mx2_x2
xsubckt_5641_a2_x2 0 9457 1 2941 2942 a2_x2
xsubckt_4752_a2_x2 0 9614 1 3673 3677 a2_x2
xsubckt_4068_nand2_x0 1 0 3916 3917 5586 nand2_x0
xsubckt_3648_a2_x2 0 4329 1 214 686 a2_x2
xsubckt_2909_nand4_x0 1 0 5054 5604 532 7689 46 nand4_x0
xsubckt_2719_a2_x2 0 5241 1 5242 7219 a2_x2
xsubckt_2485_a2_x2 0 5471 1 707 1180 a2_x2
xsubckt_1162_ao22_x2 0 6665 1 6666 6670 7038 ao22_x2
xsubckt_1408_oa22_x2 0 6432 1 6719 6441 6433 oa22_x2
xsubckt_1503_xr2_x1 6338 0 1 190 220 xr2_x1
xsubckt_1556_a2_x2 0 6285 1 7250 218 a2_x2
xsubckt_1688_nand3_x0 1 0 6153 6408 7234 209 nand3_x0
xsubckt_2220_oa22_x2 0 5731 1 5733 5739 7628 oa22_x2
xsubckt_9648_sff1_x4 1 1872 0 8828 809 sff1_x4
xsubckt_9125_sff1_x4 1 1872 0 9333 1129 sff1_x4
xsubckt_7037_o2_x2 0 8263 1 8264 7628 o2_x2
xsubckt_6884_a2_x2 0 8412 1 7407 710 a2_x2
xsubckt_6512_nand3_x0 1 0 2132 2133 2140 7613 nand3_x0
xsubckt_5189_ao22_x2 0 3319 1 600 3320 644 ao22_x2
xsubckt_4423_mx3_x2 1 0 9839 3779 3896 1496 3820 3822 mx3_x2
xsubckt_4421_mx3_x2 1 0 9841 3779 3896 1498 3826 3828 mx3_x2
xsubckt_4032_mx3_x2 1 0 3952 707 705 3953 1296 1456 mx3_x2
xsubckt_3551_oa22_x2 0 4424 1 1722 7218 4425 oa22_x2
xsubckt_2739_oa22_x2 0 5221 1 5222 705 7219 oa22_x2
xsubckt_2493_ao22_x2 0 5463 1 7596 707 7217 ao22_x2
xsubckt_1320_oa22_x2 0 152 1 1740 6526 6516 oa22_x2
xsubckt_1790_nxr2_x1 6057 1 0 6058 6292 nxr2_x1
xsubckt_9560_sff1_x4 1 1872 0 8913 1211 sff1_x4
xsubckt_9199_sff1_x4 1 1872 0 9259 666 sff1_x4
xsubckt_8748_sff1_x4 1 1872 0 9645 1270 sff1_x4
xsubckt_8660_sff1_x4 1 1872 0 9733 1447 sff1_x4
xsubckt_7055_oa22_x2 0 8245 1 7386 7625 7631 oa22_x2
xsubckt_5216_nxr2_x1 3294 1 0 3502 653 nxr2_x1
xsubckt_4429_mx3_x2 1 0 9833 3779 3896 1490 3802 3804 mx3_x2
xsubckt_4427_mx3_x2 1 0 9835 3779 3896 1492 3808 3810 mx3_x2
xsubckt_4425_mx3_x2 1 0 9837 3779 3896 1494 3814 3816 mx3_x2
xsubckt_4076_o2_x2 0 3908 1 3909 3915 o2_x2
xsubckt_2643_nand3_x0 1 0 5315 532 7689 51 nand3_x0
xsubckt_1394_oa22_x2 0 147 1 1740 6456 6446 oa22_x2
xsubckt_1469_xr2_x1 6372 0 1 186 215 xr2_x1
xsubckt_2036_nand2_x0 1 0 5833 6116 6414 nand2_x0
xsubckt_2413_o2_x2 0 5541 1 5542 5562 o2_x2
xsubckt_9556_sff1_x4 1 1872 0 8917 1216 sff1_x4
xsubckt_9033_sff1_x4 1 1872 0 9393 189 sff1_x4
xsubckt_4385_mx3_x2 1 0 9874 3782 3896 987 3829 3831 mx3_x2
xsubckt_4383_mx3_x2 1 0 9876 3782 3896 990 3835 3837 mx3_x2
xsubckt_4381_mx3_x2 1 0 9878 3782 3896 992 3841 3843 mx3_x2
xsubckt_4051_nand2_x0 1 0 3933 3934 7215 nand2_x0
xsubckt_1581_nand3_x0 1 0 6260 6286 7246 204 nand3_x0
xsubckt_8656_sff1_x4 1 1872 0 9737 1074 sff1_x4
xsubckt_7655_nand2_x0 1 0 7869 670 600 nand2_x0
xsubckt_6711_ao22_x2 0 1938 1 1939 1941 1942 ao22_x2
xsubckt_5981_nand2_x0 1 0 2652 1515 710 nand2_x0
xsubckt_4994_mx2_x2 0 3489 1 5753 3834 129 mx2_x2
xsubckt_4990_mx2_x2 0 3492 1 5753 3837 130 mx2_x2
xsubckt_4389_mx3_x2 1 0 9870 3782 3896 983 3817 3819 mx3_x2
xsubckt_4387_mx3_x2 1 0 9872 3782 3896 985 3823 3825 mx3_x2
xsubckt_3300_nor2_x0 1 0 4671 4672 4675 nor2_x0
xsubckt_3118_mx3_x2 1 0 4849 707 705 4850 1539 1667 mx3_x2
xsubckt_1224_oa22_x2 0 6606 1 6719 6615 6607 oa22_x2
xsubckt_9464_sff1_x4 1 1872 0 9002 1396 sff1_x4
xsubckt_9029_sff1_x4 1 1872 0 9397 193 sff1_x4
xsubckt_7227_inv_x0 1 0 8151 9090 inv_x0
xsubckt_7225_inv_x0 1 0 8152 9091 inv_x0
xsubckt_7223_inv_x0 1 0 8153 9089 inv_x0
xsubckt_6593_nand2_x0 1 0 2053 2054 2059 nand2_x0
xsubckt_6427_nor2_x0 1 0 2215 2216 7134 nor2_x0
xsubckt_5686_oa22_x2 0 2905 1 704 2906 703 oa22_x2
xsubckt_4998_mx2_x2 0 3486 1 5753 3831 127 mx2_x2
xsubckt_3812_oa22_x2 0 4167 1 7179 4209 4168 oa22_x2
xsubckt_3725_mx2_x2 0 4253 1 706 4254 4256 mx2_x2
xsubckt_3723_mx2_x2 0 4255 1 705 759 1623 mx2_x2
xsubckt_3721_mx2_x2 0 4257 1 705 1687 1559 mx2_x2
xsubckt_9821_sff1_x4 1 1872 0 8655 1657 sff1_x4
xsubckt_8564_sff1_x4 1 1872 0 9829 1031 sff1_x4
xsubckt_7819_mx3_x2 1 0 9022 7822 3897 1387 3871 3872 mx3_x2
xsubckt_7771_mx3_x2 1 0 9096 7828 3896 1039 3797 3798 mx3_x2
xsubckt_7515_ao22_x2 0 9199 1 7983 7982 7980 ao22_x2
xsubckt_7070_ao22_x2 0 8230 1 534 532 678 ao22_x2
xsubckt_6258_ao22_x2 0 2381 1 7628 2386 708 ao22_x2
xsubckt_4027_ao22_x2 0 3957 1 4009 4006 4007 ao22_x2
xsubckt_3363_oa22_x2 0 4609 1 1630 705 707 oa22_x2
xsubckt_2912_oa22_x2 0 5051 1 5075 5059 5052 oa22_x2
xsubckt_1132_oa22_x2 0 6693 1 6719 6702 6694 oa22_x2
xsubckt_970_nand3_x0 1 0 6848 6849 6850 6851 nand3_x0
xsubckt_530_inv_x0 1 0 212 7261 inv_x0
xsubckt_2150_mx3_x2 1 0 453 7162 5754 204 82 114 mx3_x2
xsubckt_2231_ao22_x2 0 5720 1 5722 5728 7628 ao22_x2
xsubckt_9895_sff1_x4 1 1872 0 8581 342 sff1_x4
xsubckt_9817_sff1_x4 1 1872 0 8659 1662 sff1_x4
xsubckt_9372_sff1_x4 1 1872 0 9089 349 sff1_x4
xsubckt_8995_sff1_x4 1 1872 0 9430 506 sff1_x4
xsubckt_8921_sff1_x4 1 1872 0 9472 1838 sff1_x4
xsubckt_7039_mx3_x2 1 0 8261 712 710 8262 1584 720 mx3_x2
xsubckt_6335_nor2_x0 1 0 2305 2306 7134 nor2_x0
xsubckt_5358_ao22_x2 0 3162 1 3172 3167 3165 ao22_x2
xsubckt_5270_ao22_x2 0 3244 1 3245 3246 3250 ao22_x2
xsubckt_2890_mx3_x2 1 0 5073 707 705 5074 937 1097 mx3_x2
xsubckt_2463_oa22_x2 0 5492 1 5493 5499 7216 oa22_x2
xsubckt_991_a2_x2 0 6828 1 7143 1869 a2_x2
xsubckt_796_a2_x2 0 7014 1 701 76 a2_x2
xsubckt_756_a2_x2 0 7052 1 7686 229 a2_x2
xsubckt_536_inv_x0 1 0 1811 7255 inv_x0
xsubckt_143_inv_x0 1 0 647 7648 inv_x0
xsubckt_141_inv_x0 1 0 375 7650 inv_x0
xsubckt_532_inv_x0 1 0 210 7259 inv_x0
xsubckt_534_inv_x0 1 0 208 7257 inv_x0
xsubckt_1524_nxr2_x1 6317 1 0 196 226 nxr2_x1
xsubckt_2152_mx3_x2 1 0 451 7162 5754 202 80 112 mx3_x2
xsubckt_2154_mx3_x2 1 0 449 7162 5754 200 78 110 mx3_x2
xsubckt_2156_mx3_x2 1 0 477 7162 5754 228 106 138 mx3_x2
xsubckt_9368_sff1_x4 1 1872 0 9093 365 sff1_x4
xsubckt_8917_sff1_x4 1 1872 0 9476 1842 sff1_x4
xsubckt_8472_sff1_x4 1 1872 0 9921 1517 sff1_x4
xsubckt_6720_mx2_x2 0 8573 1 710 920 792 mx2_x2
xsubckt_5343_a4_x2 0 3177 1 3212 3471 3474 3477 a4_x2
xsubckt_3158_nand2_x0 1 0 4810 4811 7218 nand2_x0
xsubckt_2761_mx2_x2 0 5200 1 705 1131 971 mx2_x2
xsubckt_1032_a3_x2 1 6789 0 6790 6791 6878 a3_x2
xsubckt_538_inv_x0 1 0 446 7253 inv_x0
xsubckt_149_inv_x0 1 0 408 7642 inv_x0
xsubckt_147_inv_x0 1 0 403 7644 inv_x0
xsubckt_145_inv_x0 1 0 405 7646 inv_x0
xsubckt_490_inv_x0 1 0 84 7301 inv_x0
xsubckt_492_inv_x0 1 0 83 7299 inv_x0
xsubckt_2158_mx3_x2 1 0 475 7162 5754 226 104 136 mx3_x2
xsubckt_2370_mx2_x2 0 5584 1 705 1224 1096 mx2_x2
xsubckt_2418_mx2_x2 0 5536 1 7109 6955 7015 mx2_x2
xsubckt_9725_sff1_x4 1 1872 0 8751 761 sff1_x4
xsubckt_9280_sff1_x4 1 1872 0 9181 687 sff1_x4
xsubckt_9202_sff1_x4 1 1872 0 9256 657 sff1_x4
xsubckt_8468_sff1_x4 1 1872 0 9925 1543 sff1_x4
xsubckt_8380_sff1_x4 1 1872 0 10005 1567 sff1_x4
xsubckt_7475_a4_x2 0 7986 1 7202 7697 40 481 a4_x2
xsubckt_7328_a3_x2 1 8077 0 8079 8080 7670 a3_x2
xsubckt_6724_mx2_x2 0 8569 1 712 8572 8573 mx2_x2
xsubckt_6722_mx2_x2 0 8571 1 7625 7431 7434 mx2_x2
xsubckt_5602_nand3_x0 1 0 2969 2975 1832 1833 nand3_x0
xsubckt_5304_a2_x2 0 3213 1 3215 600 a2_x2
xsubckt_3915_ao22_x2 0 4067 1 5594 5609 7258 ao22_x2
xsubckt_3231_nand2_x0 1 0 4738 7152 7267 nand2_x0
xsubckt_1126_nand2_x0 1 0 6699 1828 589 nand2_x0
xsubckt_810_xr2_x1 7001 0 1 690 65 xr2_x1
xsubckt_494_inv_x0 1 0 401 7297 inv_x0
xsubckt_496_inv_x0 1 0 399 7295 inv_x0
xsubckt_498_inv_x0 1 0 398 7293 inv_x0
xsubckt_1994_oa22_x2 0 5872 1 6398 5883 5873 oa22_x2
xsubckt_2096_nand2_x0 1 0 444 5783 5786 nand2_x0
xsubckt_2376_mx2_x2 0 5578 1 705 1512 1352 mx2_x2
xsubckt_9799_sff1_x4 1 1872 0 8677 1672 sff1_x4
xsubckt_9276_sff1_x4 1 1872 0 9185 683 sff1_x4
xsubckt_8825_sff1_x4 1 1872 0 9568 49 sff1_x4
xsubckt_8302_sff1_x4 1 1872 0 10083 218 sff1_x4
xsubckt_7631_a2_x2 0 7889 1 667 600 a2_x2
xsubckt_6925_nand2_x0 1 0 8372 8373 7631 nand2_x0
xsubckt_5800_mx2_x2 0 2826 1 710 1448 1288 mx2_x2
xsubckt_5491_a3_x2 1 3050 0 3055 1865 1866 a3_x2
xsubckt_4716_nand4_x0 1 0 3700 3718 3745 1801 1800 nand4_x0
xsubckt_2696_a4_x2 0 5263 1 5604 532 7689 50 a4_x2
xsubckt_1036_nand2_x0 1 0 6785 1832 589 nand2_x0
xsubckt_1428_nxr2_x1 6413 1 0 180 209 nxr2_x1
xsubckt_1643_nand3_x0 1 0 6198 6200 6202 6330 nand3_x0
xsubckt_1758_ao22_x2 0 6086 1 6133 6088 6111 ao22_x2
xsubckt_2367_oa22_x2 0 5587 1 5592 7662 532 oa22_x2
xsubckt_9633_sff1_x4 1 1872 0 8840 850 sff1_x4
xsubckt_9110_sff1_x4 1 1872 0 1917 1885 sff1_x4
xsubckt_8899_sff1_x4 1 1872 0 9494 1862 sff1_x4
xsubckt_8376_sff1_x4 1 1872 0 10009 1571 sff1_x4
xsubckt_7651_a2_x2 0 7872 1 7873 7874 a2_x2
xsubckt_7563_oa22_x2 0 7943 1 644 7679 681 oa22_x2
xsubckt_7456_a2_x2 0 8000 1 8014 8146 a2_x2
xsubckt_6954_ao22_x2 0 8344 1 711 8346 708 ao22_x2
xsubckt_6688_mx2_x2 0 1960 1 710 1497 1337 mx2_x2
xsubckt_6297_mx2_x2 0 2343 1 710 2344 2345 mx2_x2
xsubckt_6295_mx2_x2 0 2345 1 712 994 962 mx2_x2
xsubckt_6293_a2_x2 0 9399 1 2347 2389 a2_x2
xsubckt_6098_a2_x2 0 2537 1 7537 710 a2_x2
xsubckt_5022_mx2_x2 0 3468 1 5753 3813 121 mx2_x2
xsubckt_4690_a2_x2 0 9625 1 3724 3725 a2_x2
xsubckt_4670_a2_x2 0 9630 1 3741 3742 a2_x2
xsubckt_3967_a3_x2 1 4015 0 4016 4017 4019 a3_x2
xsubckt_3761_a2_x2 0 10061 1 4218 4271 a2_x2
xsubckt_3526_a2_x2 0 4449 1 705 7451 a2_x2
xsubckt_3292_a2_x2 0 4679 1 221 693 a2_x2
xsubckt_3051_nand2_x0 1 0 4915 4916 4921 nand2_x0
xsubckt_2966_nand2_x0 1 0 4999 5001 5045 nand2_x0
xsubckt_2759_nxr2_x1 5202 1 0 5203 5206 nxr2_x1
xsubckt_959_nand3_x0 1 0 6859 6863 6886 6887 nand3_x0
xsubckt_1279_a2_x2 0 6554 1 213 1739 a2_x2
xsubckt_1494_a2_x2 0 6347 1 6348 6353 a2_x2
xsubckt_1847_mx2_x2 0 6006 1 574 6007 6226 mx2_x2
xsubckt_9184_sff1_x4 1 1872 0 9274 577 sff1_x4
xsubckt_8733_sff1_x4 1 1872 0 9660 1286 sff1_x4
xsubckt_7537_nand2_x0 1 0 9193 7964 7965 nand2_x0
xsubckt_6299_mx2_x2 0 2341 1 712 1218 1186 mx2_x2
xsubckt_6228_oa22_x2 0 2410 1 7631 2411 711 oa22_x2
xsubckt_6221_o2_x2 0 2417 1 1668 710 o2_x2
xsubckt_5873_a2_x2 0 2754 1 2755 7625 a2_x2
xsubckt_5863_nand2_x0 1 0 2764 2765 7631 nand2_x0
xsubckt_5773_nand2_x0 1 0 2850 7082 531 nand2_x0
xsubckt_5764_mx2_x2 0 9419 1 2856 457 494 mx2_x2
xsubckt_5762_mx2_x2 0 9421 1 2856 459 496 mx2_x2
xsubckt_5760_mx2_x2 0 9423 1 2856 461 498 mx2_x2
xsubckt_5026_mx2_x2 0 3465 1 5753 3810 120 mx2_x2
xsubckt_4955_oa22_x2 0 9565 1 7168 3519 3521 oa22_x2
xsubckt_4789_a2_x2 0 9606 1 3644 3647 a2_x2
xsubckt_4719_ao22_x2 0 3698 1 1799 3701 40 ao22_x2
xsubckt_4622_mx3_x2 1 0 9654 3765 3896 1280 3841 3843 mx3_x2
xsubckt_4620_mx3_x2 1 0 9656 3765 3896 1282 3847 3849 mx3_x2
xsubckt_4231_mx3_x2 1 0 10015 3795 3897 1547 3871 3872 mx3_x2
xsubckt_3005_o2_x2 0 4960 1 4961 706 o2_x2
xsubckt_2876_nand2_x0 1 0 5087 7217 1385 nand2_x0
xsubckt_2798_oa22_x2 0 5163 1 5192 5183 5164 oa22_x2
xsubckt_2786_nand2_x0 1 0 5175 5180 704 nand2_x0
xsubckt_731_ao22_x2 0 7072 1 7136 7149 40 ao22_x2
xsubckt_1301_oa22_x2 0 153 1 1740 6544 6534 oa22_x2
xsubckt_1459_nand4_x0 1 0 6382 6385 6390 6397 6402 nand4_x0
xsubckt_1708_xr2_x1 6133 0 1 423 207 xr2_x1
xsubckt_9629_sff1_x4 1 1872 0 8844 854 sff1_x4
xsubckt_9541_sff1_x4 1 1872 0 8932 1223 sff1_x4
xsubckt_9106_sff1_x4 1 1872 0 1921 1889 sff1_x4
xsubckt_8729_sff1_x4 1 1872 0 9664 1260 sff1_x4
xsubckt_7700_nand2_x0 1 0 7833 8018 363 nand2_x0
xsubckt_7559_oa22_x2 0 7946 1 644 7679 680 oa22_x2
xsubckt_5766_mx2_x2 0 9417 1 2856 454 491 mx2_x2
xsubckt_4628_mx3_x2 1 0 9648 3765 3896 1273 3823 3825 mx3_x2
xsubckt_4626_mx3_x2 1 0 9650 3765 3896 1275 3829 3831 mx3_x2
xsubckt_4624_mx3_x2 1 0 9652 3765 3896 1278 3835 3837 mx3_x2
xsubckt_4580_mx3_x2 1 0 9693 3768 3897 1097 3863 3864 mx3_x2
xsubckt_4237_mx3_x2 1 0 10009 3795 3896 1571 3850 3852 mx3_x2
xsubckt_4235_mx3_x2 1 0 10011 3795 3897 1573 3856 3857 mx3_x2
xsubckt_4233_mx3_x2 1 0 10013 3795 3897 1545 3863 3864 mx3_x2
xsubckt_4102_mx2_x2 0 3886 1 3896 3887 3888 mx2_x2
xsubckt_3045_o2_x2 0 4921 1 4922 4924 o2_x2
xsubckt_2919_ao22_x2 0 5045 1 5101 5049 5046 ao22_x2
xsubckt_689_nand3_x0 1 0 7111 7113 7194 40 nand3_x0
xsubckt_1227_o2_x2 0 6604 1 687 62 o2_x2
xsubckt_9092_sff1_x4 1 1872 0 1906 1874 sff1_x4
xsubckt_8641_sff1_x4 1 1872 0 9752 1090 sff1_x4
xsubckt_6571_oa22_x2 0 2075 1 40 1741 188 oa22_x2
xsubckt_5236_oa22_x2 0 3276 1 7680 3496 7167 oa22_x2
xsubckt_4977_mx3_x2 1 0 3502 5754 518 7764 7330 7331 mx3_x2
xsubckt_4973_mx3_x2 1 0 3505 5754 518 7763 7332 7333 mx3_x2
xsubckt_4709_nand3_x0 1 0 3706 3708 3709 3722 nand3_x0
xsubckt_4586_mx3_x2 1 0 9687 3768 3896 1121 3844 3846 mx3_x2
xsubckt_4584_mx3_x2 1 0 9689 3768 3896 1123 3850 3852 mx3_x2
xsubckt_4582_mx3_x2 1 0 9691 3768 3897 1125 3856 3857 mx3_x2
xsubckt_4239_mx3_x2 1 0 10007 3795 3896 1569 3844 3846 mx3_x2
xsubckt_4193_mx3_x2 1 0 10030 3899 3896 1591 3817 3819 mx3_x2
xsubckt_4108_mx2_x2 0 10050 1 3898 3882 1582 mx2_x2
xsubckt_4106_mx2_x2 0 3883 1 518 82 1878 mx2_x2
xsubckt_3379_o2_x2 0 4593 1 705 1022 o2_x2
xsubckt_727_ao22_x2 0 7076 1 7136 7149 533 ao22_x2
xsubckt_65_inv_x0 1 0 49 7726 inv_x0
xsubckt_63_inv_x0 1 0 47 7728 inv_x0
xsubckt_61_inv_x0 1 0 75 7730 inv_x0
xsubckt_1574_ao22_x2 0 6267 1 6285 6272 6270 ao22_x2
xsubckt_1732_oa22_x2 0 6109 1 6110 6117 6137 oa22_x2
xsubckt_1931_ao22_x2 0 5930 1 6335 5948 6183 ao22_x2
xsubckt_9537_sff1_x4 1 1872 0 10101 1739 sff1_x4
xsubckt_9014_sff1_x4 1 1872 0 9412 446 sff1_x4
xsubckt_8637_sff1_x4 1 1872 0 9756 1094 sff1_x4
xsubckt_8021_mx2_x2 0 8832 1 7809 3878 813 mx2_x2
xsubckt_5842_nand3_x0 1 0 2784 2786 2788 5743 nand3_x0
xsubckt_4588_mx3_x2 1 0 9685 3768 3896 1119 3838 3840 mx3_x2
xsubckt_4197_mx3_x2 1 0 10029 3899 3896 1590 3814 3816 mx3_x2
xsubckt_3313_mx3_x2 1 0 4658 704 7215 4659 4666 4668 mx3_x2
xsubckt_2939_o2_x2 0 5025 1 5026 703 o2_x2
xsubckt_701_a3_x2 1 7100 0 644 40 1742 a3_x2
xsubckt_69_inv_x0 1 0 1754 7722 inv_x0
xsubckt_67_inv_x0 1 0 51 7724 inv_x0
xsubckt_2105_oa22_x2 0 5775 1 7685 308 7242 oa22_x2
xsubckt_2304_ao22_x2 0 5649 1 7625 1294 5650 ao22_x2
xsubckt_2382_ao22_x2 0 5572 1 1416 705 707 ao22_x2
xsubckt_9445_sff1_x4 1 1872 0 9021 1386 sff1_x4
xsubckt_9088_sff1_x4 1 1872 0 1910 1878 sff1_x4
xsubckt_7250_nand2_x0 1 0 8132 8133 8135 nand2_x0
xsubckt_6766_ao22_x2 0 8528 1 1463 710 712 ao22_x2
xsubckt_3924_mx2_x2 0 4058 1 705 1715 883 mx2_x2
xsubckt_3319_mx3_x2 1 0 4652 707 705 4653 1599 735 mx3_x2
xsubckt_3273_mx3_x2 1 0 4697 707 705 4698 1312 1472 mx3_x2
xsubckt_741_a3_x2 1 7063 0 530 1741 40 a3_x2
xsubckt_650_nor4_x0 1 0 7145 610 571 591 608 nor4_x0
xsubckt_1205_oa22_x2 0 6624 1 6719 6633 6625 oa22_x2
xsubckt_1276_nand2_x0 1 0 6557 1819 589 nand2_x0
xsubckt_9880_sff1_x4 1 1872 0 8596 1631 sff1_x4
xsubckt_9802_sff1_x4 1 1872 0 8674 1649 sff1_x4
xsubckt_8980_sff1_x4 1 1872 0 9445 493 sff1_x4
xsubckt_8545_sff1_x4 1 1872 0 9848 1506 sff1_x4
xsubckt_7972_mx3_x2 1 0 8877 7814 3896 919 3817 3819 mx3_x2
xsubckt_7970_mx3_x2 1 0 8879 7814 3896 921 3823 3825 mx3_x2
xsubckt_7574_ao22_x2 0 9185 1 7956 7935 7937 ao22_x2
xsubckt_7375_oa22_x2 0 8042 1 7679 644 7693 oa22_x2
xsubckt_7105_mx2_x2 0 8196 1 710 1711 879 mx2_x2
xsubckt_7103_mx2_x2 0 8198 1 710 1487 1327 mx2_x2
xsubckt_6475_oa22_x2 0 2169 1 2170 710 7628 oa22_x2
xsubckt_6100_nand2_x0 1 0 2535 2536 712 nand2_x0
xsubckt_5866_ao22_x2 0 2761 1 2762 2768 7613 ao22_x2
xsubckt_5055_nand2_x0 1 0 3442 3541 7648 nand2_x0
xsubckt_3381_nand2_x0 1 0 4591 4592 4594 nand2_x0
xsubckt_3275_mx3_x2 1 0 4695 707 705 4696 1056 1184 mx3_x2
xsubckt_3144_mx2_x2 0 4824 1 705 1218 1090 mx2_x2
xsubckt_2585_nand3_x0 1 0 5372 6898 7108 7152 nand3_x0
xsubckt_867_oa22_x2 0 6947 1 6965 6966 6967 oa22_x2
xsubckt_1390_ao22_x2 0 6449 1 6450 6454 7038 ao22_x2
xsubckt_2068_nand2_x0 1 0 5804 6116 6427 nand2_x0
xsubckt_2290_ao22_x2 0 5662 1 5663 5676 5743 ao22_x2
xsubckt_9876_sff1_x4 1 1872 0 8600 1635 sff1_x4
xsubckt_9353_sff1_x4 1 1872 0 9108 1053 sff1_x4
xsubckt_8902_sff1_x4 1 1872 0 9491 1858 sff1_x4
xsubckt_7978_mx3_x2 1 0 8871 7814 3896 912 3799 3801 mx3_x2
xsubckt_7976_mx3_x2 1 0 8873 7814 3896 915 3805 3807 mx3_x2
xsubckt_7974_mx3_x2 1 0 8875 7814 3896 917 3811 3813 mx3_x2
xsubckt_7194_mx3_x2 1 0 9331 8158 3897 1157 3856 3857 mx3_x2
xsubckt_7192_mx3_x2 1 0 9333 8158 3897 1129 3863 3864 mx3_x2
xsubckt_7190_mx3_x2 1 0 9335 8158 3897 1131 3871 3872 mx3_x2
xsubckt_7109_mx2_x2 0 8192 1 710 1199 1071 mx2_x2
xsubckt_7107_mx2_x2 0 8194 1 7631 8195 8196 mx2_x2
xsubckt_6274_nand3_x0 1 0 2365 2366 2373 7613 nand3_x0
xsubckt_5700_ao22_x2 0 2891 1 2892 2895 703 ao22_x2
xsubckt_3884_mx2_x2 0 4097 1 705 1396 1236 mx2_x2
xsubckt_3148_mx2_x2 0 4820 1 705 1698 1570 mx2_x2
xsubckt_3020_ao22_x2 0 10074 1 4946 4995 5003 ao22_x2
xsubckt_3002_a3_x2 1 4963 0 4964 4969 7215 a3_x2
xsubckt_928_a2_x2 0 6889 1 672 47 a2_x2
xsubckt_908_a2_x2 0 6908 1 673 48 a2_x2
xsubckt_755_nand2_x0 1 0 7053 307 229 nand2_x0
xsubckt_340_inv_x0 1 0 1530 7451 inv_x0
xsubckt_342_inv_x0 1 0 1402 7449 inv_x0
xsubckt_344_inv_x0 1 0 1242 7447 inv_x0
xsubckt_2141_nand2_x0 1 0 424 5757 5772 nand2_x0
xsubckt_9710_sff1_x4 1 1872 0 8766 747 sff1_x4
xsubckt_8976_sff1_x4 1 1872 0 149 86 sff1_x4
xsubckt_8453_sff1_x4 1 1872 0 9940 734 sff1_x4
xsubckt_7849_mx2_x2 0 8994 1 7819 3886 1169 mx2_x2
xsubckt_7847_mx2_x2 0 8996 1 7819 3892 1191 mx2_x2
xsubckt_7687_nand2_x0 1 0 7843 7844 7846 nand2_x0
xsubckt_7198_mx3_x2 1 0 9327 8158 3896 1153 3844 3846 mx3_x2
xsubckt_7196_mx3_x2 1 0 9329 8158 3896 1155 3850 3852 mx3_x2
xsubckt_7063_mx2_x2 0 8237 1 710 1712 880 mx2_x2
xsubckt_5835_nand2_x0 1 0 2791 2803 711 nand2_x0
xsubckt_4874_ao22_x2 0 3579 1 1759 3580 40 ao22_x2
xsubckt_3900_ao22_x2 0 4081 1 4082 4086 703 ao22_x2
xsubckt_3708_nor2_x0 1 0 4270 213 685 nor2_x0
xsubckt_1021_oa22_x2 0 168 1 6815 6813 6800 oa22_x2
xsubckt_988_a2_x2 0 6831 1 6832 6878 a2_x2
xsubckt_346_inv_x0 1 0 1082 7445 inv_x0
xsubckt_348_inv_x0 1 0 986 7443 inv_x0
xsubckt_1308_ao22_x2 0 6527 1 6550 6547 6548 ao22_x2
xsubckt_1579_nxr2_x1 6262 1 0 420 204 nxr2_x1
xsubckt_1966_nand2_x0 1 0 1921 5898 5902 nand2_x0
xsubckt_9784_sff1_x4 1 1872 0 8692 1695 sff1_x4
xsubckt_9349_sff1_x4 1 1872 0 9112 1057 sff1_x4
xsubckt_9261_sff1_x4 1 1872 0 9200 316 sff1_x4
xsubckt_8810_sff1_x4 1 1872 0 9583 1757 sff1_x4
xsubckt_7647_a4_x2 0 7876 1 531 352 7679 644 a4_x2
xsubckt_7266_a3_x2 1 8120 0 373 372 371 a3_x2
xsubckt_7246_a3_x2 1 8135 0 2853 7679 644 a3_x2
xsubckt_7060_a2_x2 0 8240 1 7385 710 a2_x2
xsubckt_7020_a2_x2 0 8279 1 8280 7628 a2_x2
xsubckt_6532_mx2_x2 0 2113 1 7625 7478 7480 mx2_x2
xsubckt_6141_mx2_x2 0 2495 1 710 1734 902 mx2_x2
xsubckt_5623_a3_x2 1 2954 0 2959 1825 1827 a3_x2
xsubckt_5001_mx3_x2 1 0 3484 5754 518 7770 7318 7319 mx3_x2
xsubckt_4686_a4_x2 0 3726 1 3727 3739 1745 1744 a4_x2
xsubckt_3803_nand2_x0 1 0 4176 7152 7257 nand2_x0
xsubckt_3539_ao22_x2 0 4436 1 4437 4452 704 ao22_x2
xsubckt_2875_oa22_x2 0 5088 1 5089 5092 7218 oa22_x2
xsubckt_2575_mx2_x2 0 5382 1 7217 7584 7586 mx2_x2
xsubckt_1936_nxr2_x1 5925 1 0 5926 6360 nxr2_x1
xsubckt_2180_mx2_x2 0 10090 1 5752 9080 653 mx2_x2
xsubckt_2182_mx2_x2 0 10089 1 5752 9079 652 mx2_x2
xsubckt_2184_mx2_x2 0 10088 1 5752 9078 651 mx2_x2
xsubckt_9706_sff1_x4 1 1872 0 8770 753 sff1_x4
xsubckt_8884_sff1_x4 1 1872 0 9509 1859 sff1_x4
xsubckt_8806_sff1_x4 1 1872 0 9587 1761 sff1_x4
xsubckt_8449_sff1_x4 1 1872 0 9944 738 sff1_x4
xsubckt_8361_sff1_x4 1 1872 0 10024 1584 sff1_x4
xsubckt_8273_buf_x1 1 0 1709 8736 buf_x1
xsubckt_8271_buf_x1 1 0 1713 8738 buf_x1
xsubckt_8048_a2_x2 0 7808 1 3787 3793 a2_x2
xsubckt_7670_nand2_x0 1 0 7857 661 600 nand2_x0
xsubckt_7080_a2_x2 0 8221 1 8222 7613 a2_x2
xsubckt_6490_mx2_x2 0 2154 1 7625 7484 7486 mx2_x2
xsubckt_6151_a2_x2 0 2485 1 2486 7628 a2_x2
xsubckt_6147_mx2_x2 0 2489 1 710 1510 1350 mx2_x2
xsubckt_6145_mx2_x2 0 2491 1 712 2492 2493 mx2_x2
xsubckt_6143_mx2_x2 0 2493 1 710 1190 1062 mx2_x2
xsubckt_5551_nand4_x0 1 0 3006 3015 1847 1849 1850 nand4_x0
xsubckt_5468_a3_x2 1 9504 0 3067 3068 40 a3_x2
xsubckt_5005_mx3_x2 1 0 3481 5754 518 7771 7316 7317 mx3_x2
xsubckt_4754_a3_x2 1 3671 0 3672 3676 3696 a3_x2
xsubckt_3571_a3_x2 1 4404 0 4405 4406 4408 a3_x2
xsubckt_1157_a2_x2 0 6670 1 7143 1861 a2_x2
xsubckt_767_mx2_x2 0 7041 1 307 308 229 mx2_x2
xsubckt_1518_nand2_x0 1 0 6323 7243 225 nand2_x0
xsubckt_2186_mx2_x2 0 10087 1 5752 9077 650 mx2_x2
xsubckt_2188_mx2_x2 0 10086 1 5752 9076 666 mx2_x2
xsubckt_9692_sff1_x4 1 1872 0 8784 794 sff1_x4
xsubckt_9257_sff1_x4 1 1872 0 9204 321 sff1_x4
xsubckt_8357_sff1_x4 1 1872 0 10028 1589 sff1_x4
xsubckt_8279_buf_x1 1 0 1733 8730 buf_x1
xsubckt_8277_buf_x1 1 0 1705 8732 buf_x1
xsubckt_8275_buf_x1 1 0 1707 8734 buf_x1
xsubckt_7628_a2_x2 0 9174 1 7892 7896 a2_x2
xsubckt_7394_a2_x2 0 8025 1 8026 8038 a2_x2
xsubckt_7059_nand2_x0 1 0 8241 8242 711 nand2_x0
xsubckt_6935_ao22_x2 0 8362 1 7625 948 8363 ao22_x2
xsubckt_6887_mx2_x2 0 8409 1 710 1717 885 mx2_x2
xsubckt_6660_a2_x2 0 9391 1 1988 2034 a2_x2
xsubckt_6465_a2_x2 0 2178 1 2179 2190 a2_x2
xsubckt_6149_mx2_x2 0 2487 1 709 2488 2491 mx2_x2
xsubckt_5731_a2_x2 0 9447 1 2861 2916 a2_x2
xsubckt_5576_a2_x2 0 2988 1 2991 1840 a2_x2
xsubckt_5391_oa22_x2 0 3132 1 3143 3141 3142 oa22_x2
xsubckt_5313_oa22_x2 0 3205 1 3481 3484 7672 oa22_x2
xsubckt_5009_mx3_x2 1 0 3478 5754 518 7772 7314 7315 mx3_x2
xsubckt_4822_a2_x2 0 9598 1 3619 3620 a2_x2
xsubckt_3623_nand2_x0 1 0 4353 7217 729 nand2_x0
xsubckt_3533_nand2_x0 1 0 4442 4443 707 nand2_x0
xsubckt_2488_nand2_x0 1 0 5468 5469 5472 nand2_x0
xsubckt_1197_a2_x2 0 6632 1 7143 1858 a2_x2
xsubckt_1651_ao22_x2 0 6190 1 6193 6196 6336 ao22_x2
xsubckt_9688_sff1_x4 1 1872 0 8788 799 sff1_x4
xsubckt_9614_sff1_x4 1 1872 0 8859 870 sff1_x4
xsubckt_8792_sff1_x4 1 1872 0 9601 1777 sff1_x4
xsubckt_8714_sff1_x4 1 1872 0 9679 1112 sff1_x4
xsubckt_7544_oa22_x2 0 7959 1 644 7679 677 oa22_x2
xsubckt_7312_nand2_x0 1 0 9291 8089 8090 nand2_x0
xsubckt_6784_nand3_x0 1 0 8510 8511 8518 7613 nand3_x0
xsubckt_6486_ao22_x2 0 2158 1 2169 2171 708 ao22_x2
xsubckt_5963_mx2_x2 0 2669 1 710 1484 1324 mx2_x2
xsubckt_4687_a2_x2 0 9626 1 3728 3729 a2_x2
xsubckt_4430_mx3_x2 1 0 9832 3779 3896 1488 3799 3801 mx3_x2
xsubckt_3443_nand2_x0 1 0 4530 7152 7263 nand2_x0
xsubckt_1360_oa22_x2 0 6478 1 6496 6491 6495 oa22_x2
xsubckt_1666_a2_x2 0 6175 1 6176 6179 a2_x2
xsubckt_9522_sff1_x4 1 1872 0 8944 954 sff1_x4
xsubckt_9165_sff1_x4 1 1872 0 9293 610 sff1_x4
xsubckt_8788_sff1_x4 1 1872 0 9605 1781 sff1_x4
xsubckt_8002_mx3_x2 1 0 8849 7812 3896 859 3829 3831 mx3_x2
xsubckt_8000_mx3_x2 1 0 8851 7812 3896 862 3835 3837 mx3_x2
xsubckt_7294_ao22_x2 0 8102 1 645 7680 586 ao22_x2
xsubckt_6408_ao22_x2 0 2234 1 2239 2237 2235 ao22_x2
xsubckt_6121_oa22_x2 0 2515 1 40 1741 198 oa22_x2
xsubckt_5969_mx2_x2 0 2663 1 712 2664 2665 mx2_x2
xsubckt_5967_mx2_x2 0 2665 1 710 1388 1228 mx2_x2
xsubckt_5965_mx2_x2 0 2667 1 710 1708 876 mx2_x2
xsubckt_5508_ao22_x2 0 3037 1 3042 1861 40 ao22_x2
xsubckt_5256_nxr2_x1 3257 1 0 3275 3492 nxr2_x1
xsubckt_3955_nor2_x0 1 0 4027 4028 704 nor2_x0
xsubckt_2978_ao22_x2 0 4987 1 4992 4990 4988 ao22_x2
xsubckt_1158_nand2_x0 1 0 6669 588 1797 nand2_x0
xsubckt_1411_nand2_x0 1 0 6430 7237 205 nand2_x0
xsubckt_1724_nor2_x0 1 0 6117 571 572 nor2_x0
xsubckt_1879_oa22_x2 0 5977 1 194 224 574 oa22_x2
xsubckt_9596_sff1_x4 1 1872 0 8877 919 sff1_x4
xsubckt_9073_sff1_x4 1 1872 0 9353 1304 sff1_x4
xsubckt_8622_sff1_x4 1 1872 0 9771 1460 sff1_x4
xsubckt_8006_mx3_x2 1 0 8845 7812 3896 855 3817 3819 mx3_x2
xsubckt_8004_mx3_x2 1 0 8847 7812 3896 857 3823 3825 mx3_x2
xsubckt_6957_nand2_x0 1 0 8341 8342 7631 nand2_x0
xsubckt_6922_o2_x2 0 8375 1 1364 710 o2_x2
xsubckt_6394_ao22_x2 0 2248 1 7628 2253 708 ao22_x2
xsubckt_6160_nand2_x0 1 0 2477 2478 7631 nand2_x0
xsubckt_5295_oa22_x2 0 3221 1 3224 3225 7690 oa22_x2
xsubckt_4392_mx3_x2 1 0 9867 3782 3896 980 3808 3810 mx3_x2
xsubckt_4390_mx3_x2 1 0 9869 3782 3896 982 3814 3816 mx3_x2
xsubckt_3257_o2_x2 0 4713 1 4714 7216 o2_x2
xsubckt_979_nxr2_x1 6840 1 0 700 75 nxr2_x1
xsubckt_891_nxr2_x1 6924 1 0 6925 6928 nxr2_x1
xsubckt_817_nand2_x0 1 0 6994 1843 589 nand2_x0
xsubckt_1791_oa22_x2 0 1908 1 6111 6057 6061 oa22_x2
xsubckt_9518_sff1_x4 1 1872 0 8948 959 sff1_x4
xsubckt_9430_sff1_x4 1 1872 0 9036 1364 sff1_x4
xsubckt_8696_sff1_x4 1 1872 0 9697 1101 sff1_x4
xsubckt_8222_mx2_x2 0 8611 1 7797 3890 1628 mx2_x2
xsubckt_8220_mx2_x2 0 8613 1 7797 3894 1640 mx2_x2
xsubckt_8008_mx3_x2 1 0 8843 7812 3896 853 3811 3813 mx3_x2
xsubckt_7645_nand4_x0 1 0 7877 7878 7951 7957 8140 nand4_x0
xsubckt_7360_oa22_x2 0 9279 1 8076 8053 8054 oa22_x2
xsubckt_6751_ao22_x2 0 8542 1 534 532 686 ao22_x2
xsubckt_6316_ao22_x2 0 2324 1 2329 2327 2325 ao22_x2
xsubckt_5217_oa22_x2 0 3293 1 3310 3308 3309 oa22_x2
xsubckt_4890_o2_x2 0 3566 1 3567 3631 o2_x2
xsubckt_4396_mx3_x2 1 0 9863 3782 3896 975 3797 3798 mx3_x2
xsubckt_4394_mx3_x2 1 0 9865 3782 3896 978 3802 3804 mx3_x2
xsubckt_4265_mx2_x2 0 9984 1 3791 3874 876 mx2_x2
xsubckt_4263_mx2_x2 0 9986 1 3791 3882 878 mx2_x2
xsubckt_4261_mx2_x2 0 9988 1 3791 3890 892 mx2_x2
xsubckt_3766_o2_x2 0 4213 1 212 684 o2_x2
xsubckt_1585_nand3_x0 1 0 6256 6296 7248 202 nand3_x0
xsubckt_1674_o2_x2 0 6167 1 6169 6181 o2_x2
xsubckt_1938_nand2_x0 1 0 5923 6114 6363 nand2_x0
xsubckt_2113_nand2_x0 1 0 5769 194 307 nand2_x0
xsubckt_9069_sff1_x4 1 1872 0 9357 1309 sff1_x4
xsubckt_8618_sff1_x4 1 1872 0 9775 1464 sff1_x4
xsubckt_8530_sff1_x4 1 1872 0 9863 975 sff1_x4
xsubckt_8256_oa22_x2 0 7792 1 7793 7991 7700 oa22_x2
xsubckt_8228_mx2_x2 0 8605 1 7797 3866 1610 mx2_x2
xsubckt_8226_mx2_x2 0 8607 1 7797 3874 1612 mx2_x2
xsubckt_8224_mx2_x2 0 8609 1 7797 3882 1614 mx2_x2
xsubckt_7822_mx3_x2 1 0 9019 7822 3897 1414 3859 3860 mx3_x2
xsubckt_7820_mx3_x2 1 0 9021 7822 3897 1386 3867 3868 mx3_x2
xsubckt_7124_ao22_x2 0 8178 1 7791 8183 8179 ao22_x2
xsubckt_6509_nand2_x0 1 0 2135 2136 7631 nand2_x0
xsubckt_6025_oa22_x2 0 2609 1 40 1741 176 oa22_x2
xsubckt_5545_nor3_x0 1 0 9483 3011 3012 7702 nor3_x0
xsubckt_4267_mx2_x2 0 9982 1 3791 3866 874 mx2_x2
xsubckt_2720_ao22_x2 0 5240 1 1388 705 707 ao22_x2
xsubckt_2595_oa22_x2 0 5362 1 5595 5608 207 oa22_x2
xsubckt_1141_nand2_x0 1 0 6685 588 1798 nand2_x0
xsubckt_852_oa22_x2 0 6961 1 7041 7126 7636 oa22_x2
xsubckt_1183_nor2_x0 1 0 6645 6646 6647 nor2_x0
xsubckt_9861_sff1_x4 1 1872 0 8615 1232 sff1_x4
xsubckt_9426_sff1_x4 1 1872 0 9040 1368 sff1_x4
xsubckt_8186_mx2_x2 0 8645 1 7799 3894 1256 mx2_x2
xsubckt_7828_mx3_x2 1 0 9013 7822 3896 1408 3841 3843 mx3_x2
xsubckt_7826_mx3_x2 1 0 9015 7822 3896 1410 3847 3849 mx3_x2
xsubckt_7824_mx3_x2 1 0 9017 7822 3896 1412 3853 3855 mx3_x2
xsubckt_3616_ao22_x2 0 4360 1 4361 4363 706 ao22_x2
xsubckt_2517_oa22_x2 0 5439 1 1276 705 707 oa22_x2
xsubckt_1668_nand2_x0 1 0 6173 7229 214 nand2_x0
xsubckt_2450_nand3_x0 1 0 5505 5506 5510 7216 nand3_x0
xsubckt_8961_sff1_x4 1 1872 0 165 102 sff1_x4
xsubckt_8526_sff1_x4 1 1872 0 9867 980 sff1_x4
xsubckt_8188_mx2_x2 0 8643 1 7799 3890 1244 mx2_x2
xsubckt_7786_mx3_x2 1 0 9051 7826 3896 1380 3853 3855 mx3_x2
xsubckt_7784_mx3_x2 1 0 9053 7826 3897 1382 3859 3860 mx3_x2
xsubckt_7782_mx3_x2 1 0 9055 7826 3897 1354 3867 3868 mx3_x2
xsubckt_7552_nand2_x0 1 0 7951 7953 352 nand2_x0
xsubckt_6670_nand2_x0 1 0 1978 1979 1980 nand2_x0
xsubckt_5199_oa22_x2 0 3310 1 3316 3317 3318 oa22_x2
xsubckt_4172_nxr2_x1 3832 1 0 3836 7738 nxr2_x1
xsubckt_3760_oa22_x2 0 4218 1 7179 4263 4219 oa22_x2
xsubckt_3167_ao22_x2 0 4801 1 7498 7217 707 ao22_x2
xsubckt_2947_mx3_x2 1 0 5017 707 705 5018 966 1126 mx3_x2
xsubckt_2550_mx3_x2 1 0 5407 707 705 5408 1041 1169 mx3_x2
xsubckt_846_a2_x2 0 6967 1 676 51 a2_x2
xsubckt_543_inv_x0 1 0 418 7248 inv_x0
xsubckt_541_inv_x0 1 0 434 7250 inv_x0
xsubckt_150_inv_x0 1 0 365 7641 inv_x0
xsubckt_1831_nand2_x0 1 0 6020 6114 6313 nand2_x0
xsubckt_2161_mx3_x2 1 0 472 7162 5754 223 101 133 mx3_x2
xsubckt_2163_mx3_x2 1 0 470 7162 5754 221 99 131 mx3_x2
xsubckt_2421_mx2_x2 0 10085 1 5593 5534 230 mx2_x2
xsubckt_9857_sff1_x4 1 1872 0 8619 1237 sff1_x4
xsubckt_9334_sff1_x4 1 1872 0 9127 1064 sff1_x4
xsubckt_8957_sff1_x4 1 1872 0 169 106 sff1_x4
xsubckt_8434_sff1_x4 1 1872 0 9959 879 sff1_x4
xsubckt_7788_mx3_x2 1 0 9049 7826 3896 1378 3847 3849 mx3_x2
xsubckt_7632_nor2_x0 1 0 7888 7889 7890 nor2_x0
xsubckt_6908_mx3_x2 1 0 8389 712 710 8391 7395 7397 mx3_x2
xsubckt_6813_oa22_x2 0 8482 1 982 710 712 oa22_x2
xsubckt_6580_nand2_x0 1 0 2066 2067 2068 nand2_x0
xsubckt_6402_nand2_x0 1 0 2240 2241 711 nand2_x0
xsubckt_5991_oa22_x2 0 2642 1 971 710 712 oa22_x2
xsubckt_5052_a3_x2 1 3445 0 40 128 7780 a3_x2
xsubckt_5032_a3_x2 1 3461 0 40 55 7780 a3_x2
xsubckt_5012_a3_x2 1 3476 0 40 60 7780 a3_x2
xsubckt_4904_nand3_x0 1 0 3556 3562 1753 1752 nand3_x0
xsubckt_4168_nxr2_x1 3835 1 0 3839 7737 nxr2_x1
xsubckt_3399_oa22_x2 0 4573 1 5586 4579 4576 oa22_x2
xsubckt_2949_mx3_x2 1 0 5015 707 705 5016 1062 1190 mx3_x2
xsubckt_2818_mx2_x2 0 5144 1 705 1386 1226 mx2_x2
xsubckt_2816_mx2_x2 0 5146 1 705 1098 938 mx2_x2
xsubckt_2770_mx2_x2 0 5191 1 7217 7560 7562 mx2_x2
xsubckt_1080_oa22_x2 0 6743 1 525 6899 6744 oa22_x2
xsubckt_598_ao22_x2 0 7193 1 7195 7702 484 ao22_x2
xsubckt_549_inv_x0 1 0 196 7242 inv_x0
xsubckt_547_inv_x0 1 0 194 7244 inv_x0
xsubckt_545_inv_x0 1 0 420 7246 inv_x0
xsubckt_156_inv_x0 1 0 350 7635 inv_x0
xsubckt_154_inv_x0 1 0 351 7637 inv_x0
xsubckt_152_inv_x0 1 0 354 7639 inv_x0
xsubckt_1741_nand2_x0 1 0 6101 6112 6279 nand2_x0
xsubckt_2165_mx3_x2 1 0 468 7162 5754 219 97 129 mx3_x2
xsubckt_2167_mx3_x2 1 0 465 7162 5754 216 94 126 mx3_x2
xsubckt_2169_mx3_x2 1 0 463 7162 5754 214 92 124 mx3_x2
xsubckt_2427_mx2_x2 0 5528 1 705 775 1639 mx2_x2
xsubckt_9765_sff1_x4 1 1872 0 8711 1712 sff1_x4
xsubckt_6733_mx2_x2 0 8560 1 710 1720 888 mx2_x2
xsubckt_6731_mx2_x2 0 8562 1 712 8563 8564 mx2_x2
xsubckt_6563_ao22_x2 0 2082 1 2083 2085 708 ao22_x2
xsubckt_6040_ao22_x2 0 2594 1 2595 2597 2598 ao22_x2
xsubckt_5473_a4_x2 0 3063 1 3071 1808 1809 1810 a4_x2
xsubckt_5425_nxr2_x1 3100 1 0 3101 3104 nxr2_x1
xsubckt_5072_a3_x2 1 3427 0 40 114 7780 a3_x2
xsubckt_3703_a3_x2 1 4274 0 4275 5595 5608 a3_x2
xsubckt_3601_nor2_x0 1 0 4375 4376 707 nor2_x0
xsubckt_3598_ao22_x2 0 4378 1 7219 4379 703 ao22_x2
xsubckt_3079_a3_x2 1 4887 0 4888 5595 5608 a3_x2
xsubckt_2776_mx2_x2 0 5185 1 704 5186 5189 mx2_x2
xsubckt_2774_mx2_x2 0 5187 1 7217 7565 7567 mx2_x2
xsubckt_2772_mx2_x2 0 5189 1 707 5190 5191 mx2_x2
xsubckt_158_inv_x0 1 0 349 7633 inv_x0
xsubckt_2071_a3_x2 1 5801 0 5802 5803 5804 a3_x2
xsubckt_2429_mx2_x2 0 5526 1 7217 7601 7603 mx2_x2
xsubckt_9242_sff1_x4 1 1872 0 9219 337 sff1_x4
xsubckt_8865_sff1_x4 1 1872 0 9528 133 sff1_x4
xsubckt_8342_sff1_x4 1 1872 0 10043 1605 sff1_x4
xsubckt_7617_oa22_x2 0 7901 1 644 7679 694 oa22_x2
xsubckt_6739_mx2_x2 0 8554 1 710 1176 1048 mx2_x2
xsubckt_6737_mx2_x2 0 8556 1 710 1208 1080 mx2_x2
xsubckt_6735_mx2_x2 0 8558 1 709 8559 8562 mx2_x2
xsubckt_6222_nand2_x0 1 0 2416 2417 712 nand2_x0
xsubckt_6205_nor2_x0 1 0 2432 2433 7134 nor2_x0
xsubckt_5340_nand2_x0 1 0 9519 3180 3190 nand2_x0
xsubckt_5140_a2_x2 0 3364 1 3519 659 a2_x2
xsubckt_3342_a2_x2 0 4630 1 220 692 a2_x2
xsubckt_2856_oa22_x2 0 5107 1 5595 5608 199 oa22_x2
xsubckt_967_nand2_x0 1 0 6851 587 1771 nand2_x0
xsubckt_1798_ao22_x2 0 6050 1 6297 6052 6111 ao22_x2
xsubckt_2385_mx2_x2 0 5569 1 705 1160 1000 mx2_x2
xsubckt_9673_sff1_x4 1 1872 0 8803 796 sff1_x4
xsubckt_9238_sff1_x4 1 1872 0 9223 311 sff1_x4
xsubckt_9150_sff1_x4 1 1872 0 9308 600 sff1_x4
xsubckt_6695_mx2_x2 0 1953 1 710 1017 825 mx2_x2
xsubckt_6693_mx2_x2 0 1955 1 710 1433 1273 mx2_x2
xsubckt_6559_ao22_x2 0 2086 1 1117 710 712 ao22_x2
xsubckt_5895_oa22_x2 0 2734 1 679 7080 2735 oa22_x2
xsubckt_5454_a2_x2 0 9508 1 3077 3078 a2_x2
xsubckt_5372_oa22_x2 0 3149 1 7680 3469 7167 oa22_x2
xsubckt_4760_a2_x2 0 9613 1 3666 3668 a2_x2
xsubckt_3831_a2_x2 0 4149 1 4150 7217 a2_x2
xsubckt_3187_a2_x2 0 4781 1 4782 4789 a2_x2
xsubckt_609_nand2_x0 1 0 7182 1737 483 nand2_x0
xsubckt_1349_a2_x2 0 6488 1 7143 1850 a2_x2
xsubckt_1965_a3_x2 1 5898 0 5899 5900 5901 a3_x2
xsubckt_2329_oa22_x2 0 5624 1 7631 5625 711 oa22_x2
xsubckt_8773_sff1_x4 1 1872 0 9620 1798 sff1_x4
xsubckt_8338_sff1_x4 1 1872 0 10047 1579 sff1_x4
xsubckt_6852_a2_x2 0 8444 1 8445 7625 a2_x2
xsubckt_6697_mx2_x2 0 1951 1 708 1952 1954 mx2_x2
xsubckt_6659_nand2_x0 1 0 1988 1989 1991 nand2_x0
xsubckt_6467_ao22_x2 0 2176 1 2177 2198 2729 ao22_x2
xsubckt_5819_mx2_x2 0 2807 1 7625 7627 7630 mx2_x2
xsubckt_5241_nxr2_x1 3271 1 0 3496 651 nxr2_x1
xsubckt_4995_oa22_x2 0 9555 1 7168 3489 3491 oa22_x2
xsubckt_4819_a2_x2 0 9599 1 3621 3623 a2_x2
xsubckt_4807_nand2_x0 1 0 3630 3631 7711 nand2_x0
xsubckt_4806_o4_x2 0 3631 1 3632 3670 3706 3710 o4_x2
xsubckt_4671_ao22_x2 0 3738 1 1745 3739 40 ao22_x2
xsubckt_4024_o2_x2 0 3960 1 206 678 o2_x2
xsubckt_3871_a2_x2 0 4110 1 210 682 a2_x2
xsubckt_3572_nand3_x0 1 0 4403 4404 5595 5608 nand3_x0
xsubckt_2528_ao22_x2 0 5428 1 7219 5429 7216 ao22_x2
xsubckt_1630_nand3_x0 1 0 6211 6217 6233 6242 nand3_x0
xsubckt_1998_nand2_x0 1 0 5868 6116 6403 nand2_x0
xsubckt_2083_nand2_x0 1 0 5793 176 307 nand2_x0
xsubckt_9669_sff1_x4 1 1872 0 8807 816 sff1_x4
xsubckt_9581_sff1_x4 1 1872 0 8892 905 sff1_x4
xsubckt_9146_sff1_x4 1 1872 0 9312 1136 sff1_x4
xsubckt_8201_mx3_x2 1 0 8630 7800 3896 1249 3844 3846 mx3_x2
xsubckt_7599_oa22_x2 0 7916 1 644 7679 691 oa22_x2
xsubckt_6824_ao22_x2 0 8471 1 7410 7625 712 ao22_x2
xsubckt_6822_nand2_x0 1 0 8473 8474 8476 nand2_x0
xsubckt_6569_nand2_x0 1 0 2076 2077 2079 nand2_x0
xsubckt_4846_o4_x2 0 3600 1 3605 3631 7714 7715 o4_x2
xsubckt_4635_mx3_x2 1 0 9641 3765 3896 1266 3802 3804 mx3_x2
xsubckt_4633_mx3_x2 1 0 9643 3765 3896 1268 3808 3810 mx3_x2
xsubckt_4631_mx3_x2 1 0 9645 3765 3896 1270 3814 3816 mx3_x2
xsubckt_4502_mx2_x2 0 9766 1 3772 3894 1096 mx2_x2
xsubckt_4244_mx3_x2 1 0 10002 3795 3896 1563 3829 3831 mx3_x2
xsubckt_4242_mx3_x2 1 0 10004 3795 3896 1566 3835 3837 mx3_x2
xsubckt_4240_mx3_x2 1 0 10006 3795 3896 1568 3841 3843 mx3_x2
xsubckt_4111_mx2_x2 0 3879 1 518 81 1877 mx2_x2
xsubckt_1105_ao22_x2 0 6719 1 6720 6882 1737 ao22_x2
xsubckt_1043_o2_x2 0 167 1 6779 6792 o2_x2
xsubckt_936_nor2_x0 1 0 6881 524 525 nor2_x0
xsubckt_860_nand2_x0 1 0 6953 587 1777 nand2_x0
xsubckt_2226_o2_x2 0 5725 1 5726 712 o2_x2
xsubckt_9503_sff1_x4 1 1872 0 8963 956 sff1_x4
xsubckt_8769_sff1_x4 1 1872 0 9624 1802 sff1_x4
xsubckt_8681_sff1_x4 1 1872 0 9712 1433 sff1_x4
xsubckt_8207_mx3_x2 1 0 8624 7800 3896 1242 3826 3828 mx3_x2
xsubckt_8205_mx3_x2 1 0 8626 7800 3896 1245 3832 3834 mx3_x2
xsubckt_8203_mx3_x2 1 0 8628 7800 3896 1247 3838 3840 mx3_x2
xsubckt_7433_oa22_x2 0 8016 1 644 7679 7612 oa22_x2
xsubckt_5850_nand2_x0 1 0 2777 2778 2779 nand2_x0
xsubckt_5799_oa22_x2 0 9413 1 7192 2827 2830 oa22_x2
xsubckt_4637_mx3_x2 1 0 9639 3765 3896 1263 3797 3798 mx3_x2
xsubckt_4593_mx3_x2 1 0 9680 3768 3896 1113 3823 3825 mx3_x2
xsubckt_4591_mx3_x2 1 0 9682 3768 3896 1115 3829 3831 mx3_x2
xsubckt_4508_mx2_x2 0 9760 1 3772 3874 1068 mx2_x2
xsubckt_4506_mx2_x2 0 9762 1 3772 3882 1070 mx2_x2
xsubckt_4504_mx2_x2 0 9764 1 3772 3890 1084 mx2_x2
xsubckt_4248_mx3_x2 1 0 9998 3795 3896 1559 3817 3819 mx3_x2
xsubckt_4246_mx3_x2 1 0 10000 3795 3896 1561 3823 3825 mx3_x2
xsubckt_4117_mx2_x2 0 3874 1 3896 3875 3876 mx2_x2
xsubckt_4113_mx2_x2 0 10049 1 3898 3878 1581 mx2_x2
xsubckt_2953_nand2_x0 1 0 5011 7153 7278 nand2_x0
xsubckt_2565_nor3_x0 1 0 5392 5393 5401 706 nor3_x0
xsubckt_856_nand3_x0 1 0 6957 6958 6960 6961 nand3_x0
xsubckt_72_inv_x0 1 0 1759 7719 inv_x0
xsubckt_70_inv_x0 1 0 1755 7721 inv_x0
xsubckt_1337_o2_x2 0 6499 1 6500 6501 o2_x2
xsubckt_1552_o2_x2 0 6289 1 419 203 o2_x2
xsubckt_1806_o2_x2 0 6043 1 6045 6246 o2_x2
xsubckt_9577_sff1_x4 1 1872 0 8896 909 sff1_x4
xsubckt_9054_sff1_x4 1 1872 0 9372 1294 sff1_x4
xsubckt_8677_sff1_x4 1 1872 0 9716 1438 sff1_x4
xsubckt_8603_sff1_x4 1 1872 0 9790 1450 sff1_x4
xsubckt_8209_mx3_x2 1 0 8622 7800 3896 1240 3820 3822 mx3_x2
xsubckt_8163_mx3_x2 1 0 8666 7802 3897 1669 3856 3857 mx3_x2
xsubckt_8161_mx3_x2 1 0 8668 7802 3897 1641 3863 3864 mx3_x2
xsubckt_7326_nor3_x0 1 0 8079 359 356 352 nor3_x0
xsubckt_6552_nand2_x0 1 0 2093 2094 7631 nand2_x0
xsubckt_5951_o2_x2 0 2681 1 1644 710 o2_x2
xsubckt_5475_ao22_x2 0 3061 1 3066 1808 40 ao22_x2
xsubckt_4597_mx3_x2 1 0 9676 3768 3896 1109 3811 3813 mx3_x2
xsubckt_4595_mx3_x2 1 0 9678 3768 3896 1111 3817 3819 mx3_x2
xsubckt_3717_mx3_x2 1 0 4261 707 705 4262 951 1111 mx3_x2
xsubckt_2735_o2_x2 0 5225 1 5226 5228 o2_x2
xsubckt_844_nor2_x0 1 0 6968 6969 6975 nor2_x0
xsubckt_78_inv_x0 1 0 1774 7713 inv_x0
xsubckt_76_inv_x0 1 0 1767 7715 inv_x0
xsubckt_74_inv_x0 1 0 1765 7717 inv_x0
xsubckt_1592_o2_x2 0 6249 1 176 200 o2_x2
xsubckt_1891_nand2_x0 1 0 5966 6116 6349 nand2_x0
xsubckt_1981_nand2_x0 1 0 5884 6373 6379 nand2_x0
xsubckt_9411_sff1_x4 1 1872 0 9055 1354 sff1_x4
xsubckt_8511_sff1_x4 1 1872 0 9882 996 sff1_x4
xsubckt_8169_mx3_x2 1 0 8660 7802 3896 1663 3838 3840 mx3_x2
xsubckt_8167_mx3_x2 1 0 8662 7802 3896 1665 3844 3846 mx3_x2
xsubckt_8165_mx3_x2 1 0 8664 7802 3896 1667 3850 3852 mx3_x2
xsubckt_7344_nand2_x0 1 0 8064 8138 574 nand2_x0
xsubckt_7330_nand4_x0 1 0 8075 8079 8080 7670 7671 nand4_x0
xsubckt_7254_nand2_x0 1 0 8129 8130 8135 nand2_x0
xsubckt_6959_o2_x2 0 8339 1 1651 710 o2_x2
xsubckt_5832_ao22_x2 0 2794 1 712 2795 709 ao22_x2
xsubckt_4599_mx3_x2 1 0 9674 3768 3896 1107 3805 3807 mx3_x2
xsubckt_4468_mx2_x2 0 9798 1 3774 3894 1480 mx2_x2
xsubckt_3998_o2_x2 0 3985 1 3986 3988 o2_x2
xsubckt_3719_mx3_x2 1 0 4259 707 705 4260 1047 1175 mx3_x2
xsubckt_3476_oa22_x2 0 4498 1 4508 4507 4499 oa22_x2
xsubckt_1164_nor2_x0 1 0 6663 6664 6665 nor2_x0
xsubckt_636_a3_x2 1 414 0 7202 40 481 a3_x2
xsubckt_586_nand3_x0 1 0 7205 344 343 482 nand3_x0
xsubckt_1180_nand3_x0 1 0 6648 6649 6650 6651 nand3_x0
xsubckt_1680_oa22_x2 0 6161 1 6163 6165 6383 oa22_x2
xsubckt_2344_ao22_x2 0 296 1 5610 5611 5655 ao22_x2
xsubckt_2415_nand2_x0 1 0 5539 702 230 nand2_x0
xsubckt_9842_sff1_x4 1 1872 0 8634 1253 sff1_x4
xsubckt_9485_sff1_x4 1 1872 0 8981 1184 sff1_x4
xsubckt_9407_sff1_x4 1 1872 0 9059 1358 sff1_x4
xsubckt_8585_sff1_x4 1 1872 0 9808 1017 sff1_x4
xsubckt_7503_mx2_x2 0 9207 1 7985 429 324 mx2_x2
xsubckt_7501_mx2_x2 0 9209 1 7985 431 326 mx2_x2
xsubckt_7110_mx2_x2 0 8191 1 710 751 1615 mx2_x2
xsubckt_6728_ao22_x2 0 8565 1 8566 8574 711 ao22_x2
xsubckt_4652_nor2_x0 1 0 9634 3753 3755 nor2_x0
xsubckt_3833_oa22_x2 0 4147 1 4148 705 707 oa22_x2
xsubckt_3675_mx3_x2 1 0 4302 7215 7218 4303 4314 4320 mx3_x2
xsubckt_3385_nand2_x0 1 0 4587 4588 4591 nand2_x0
xsubckt_939_nand2_x0 1 0 6878 7786 525 nand2_x0
xsubckt_704_a2_x2 0 7097 1 7680 1742 a2_x2
xsubckt_676_a3_x2 1 7120 0 7125 7130 40 a3_x2
xsubckt_2325_nand2_x0 1 0 5628 5629 711 nand2_x0
xsubckt_9393_sff1_x4 1 1872 0 9068 357 sff1_x4
xsubckt_8942_sff1_x4 1 1872 0 9451 1814 sff1_x4
xsubckt_8507_sff1_x4 1 1872 0 9886 970 sff1_x4
xsubckt_7852_mx2_x2 0 8991 1 7819 3874 1164 mx2_x2
xsubckt_7850_mx2_x2 0 8993 1 7819 3882 1166 mx2_x2
xsubckt_7509_mx2_x2 0 9201 1 7985 422 317 mx2_x2
xsubckt_7507_mx2_x2 0 9203 1 7985 425 320 mx2_x2
xsubckt_7505_mx2_x2 0 9205 1 7985 427 322 mx2_x2
xsubckt_6104_nand2_x0 1 0 2531 2532 7628 nand2_x0
xsubckt_5222_nand2_x0 1 0 9528 3289 3300 nand2_x0
xsubckt_4087_nand2_x0 1 0 3898 3900 3907 nand2_x0
xsubckt_4073_nand4_x0 1 0 3911 5604 532 7689 53 nand4_x0
xsubckt_3893_mx2_x2 0 4088 1 705 1204 1076 mx2_x2
xsubckt_3891_mx2_x2 0 4090 1 7216 4091 4093 mx2_x2
xsubckt_3634_nand3_x0 1 0 4342 4343 4530 7104 nand3_x0
xsubckt_2620_mx2_x2 0 5338 1 7217 7575 7577 mx2_x2
xsubckt_351_inv_x0 1 0 889 7440 inv_x0
xsubckt_1960_nand3_x0 1 0 5903 5905 5908 6371 nand3_x0
xsubckt_2049_oa22_x2 0 5821 1 6411 5822 5823 oa22_x2
xsubckt_9838_sff1_x4 1 1872 0 8638 1227 sff1_x4
xsubckt_9750_sff1_x4 1 1872 0 8726 1729 sff1_x4
xsubckt_9315_sff1_x4 1 1872 0 9146 1347 sff1_x4
xsubckt_8493_sff1_x4 1 1872 0 9900 1525 sff1_x4
xsubckt_7989_mx3_x2 1 0 8862 7812 3897 843 3871 3872 mx3_x2
xsubckt_7463_mx2_x2 0 9234 1 2856 7997 480 mx2_x2
xsubckt_6636_ao22_x2 0 2011 1 1466 710 712 ao22_x2
xsubckt_6113_ao22_x2 0 2522 1 2523 2525 708 ao22_x2
xsubckt_5605_a4_x2 0 2967 1 2975 1831 1832 1833 a4_x2
xsubckt_5537_oa22_x2 0 3016 1 1853 3023 1852 oa22_x2
xsubckt_3897_mx2_x2 0 4084 1 705 1460 1300 mx2_x2
xsubckt_3741_oa22_x2 0 4237 1 1271 705 707 oa22_x2
xsubckt_2626_mx2_x2 0 5332 1 705 910 782 mx2_x2
xsubckt_2624_mx2_x2 0 5334 1 707 5335 5336 mx2_x2
xsubckt_2622_mx2_x2 0 5336 1 705 1358 846 mx2_x2
xsubckt_1149_oa22_x2 0 162 1 6690 6688 6678 oa22_x2
xsubckt_922_nand2_x0 1 0 6894 1838 589 nand2_x0
xsubckt_353_inv_x0 1 0 1689 7438 inv_x0
xsubckt_355_inv_x0 1 0 1561 7436 inv_x0
xsubckt_357_inv_x0 1 0 1688 7434 inv_x0
xsubckt_1545_nxr2_x1 6296 1 0 417 201 nxr2_x1
xsubckt_2145_nand2_x0 1 0 421 5755 5764 nand2_x0
xsubckt_2235_mx2_x2 0 5716 1 710 1020 828 mx2_x2
xsubckt_2248_ao22_x2 0 5703 1 5705 5718 5743 ao22_x2
xsubckt_9389_sff1_x4 1 1872 0 9072 361 sff1_x4
xsubckt_8938_sff1_x4 1 1872 0 9455 1819 sff1_x4
xsubckt_8850_sff1_x4 1 1872 0 9543 52 sff1_x4
xsubckt_8415_sff1_x4 1 1872 0 9978 900 sff1_x4
xsubckt_7912_a4_x2 0 7816 1 3769 3901 3903 3906 a4_x2
xsubckt_6541_mx2_x2 0 2104 1 710 1693 1565 mx2_x2
xsubckt_6329_mx3_x2 1 0 2311 712 710 2312 802 930 mx3_x2
xsubckt_6109_ao22_x2 0 2526 1 1097 710 712 ao22_x2
xsubckt_6006_a2_x2 0 2627 1 2628 708 a2_x2
xsubckt_4836_ao22_x2 0 3608 1 1769 3610 40 ao22_x2
xsubckt_3807_nand2_x0 1 0 4172 7153 7262 nand2_x0
xsubckt_3737_oa22_x2 0 4241 1 4242 4245 7218 oa22_x2
xsubckt_3100_nand2_x0 1 0 4867 4868 7219 nand2_x0
xsubckt_2971_mx2_x2 0 4994 1 7217 7523 7525 mx2_x2
xsubckt_2628_mx2_x2 0 5330 1 707 5331 5332 mx2_x2
xsubckt_1119_a3_x2 1 6706 0 6707 6727 6732 a3_x2
xsubckt_1083_nand2_x0 1 0 6740 1830 589 nand2_x0
xsubckt_359_inv_x0 1 0 1592 7432 inv_x0
xsubckt_1941_oa22_x2 0 1923 1 6111 5925 5921 oa22_x2
xsubckt_1976_nxr2_x1 5888 1 0 5889 6376 nxr2_x1
xsubckt_2191_mx2_x2 0 9074 1 7199 395 363 mx2_x2
xsubckt_2237_mx2_x2 0 5714 1 710 1692 1564 mx2_x2
xsubckt_9746_sff1_x4 1 1872 0 8730 1733 sff1_x4
xsubckt_9223_sff1_x4 1 1872 0 9238 536 sff1_x4
xsubckt_8489_sff1_x4 1 1872 0 9904 1529 sff1_x4
xsubckt_8280_buf_x1 1 0 1732 8729 buf_x1
xsubckt_7676_oa22_x2 0 7852 1 644 7679 674 oa22_x2
xsubckt_6936_mx2_x2 0 8361 1 710 1140 980 mx2_x2
xsubckt_6287_mx3_x2 1 0 2352 7628 7613 2353 2359 2361 mx3_x2
xsubckt_6285_mx3_x2 1 0 2354 712 710 2355 803 931 mx3_x2
xsubckt_6021_ao22_x2 0 2612 1 534 532 673 ao22_x2
xsubckt_5538_a3_x2 1 9485 0 3016 3017 40 a3_x2
xsubckt_5392_nxr2_x1 3131 1 0 3463 665 nxr2_x1
xsubckt_5137_a2_x2 0 3367 1 3373 3519 a2_x2
xsubckt_5121_ao22_x2 0 3381 1 644 3525 7168 ao22_x2
xsubckt_4824_a3_x2 1 3617 0 3622 1774 1772 a3_x2
xsubckt_4066_nand3_x0 1 0 3918 3919 3926 703 nand3_x0
xsubckt_2979_mx2_x2 0 4986 1 706 1221 1157 mx2_x2
xsubckt_828_nand3_x0 1 0 6984 6985 6987 6988 nand3_x0
xsubckt_752_o2_x2 0 10100 1 7055 7057 o2_x2
xsubckt_1508_nand4_x0 1 0 6333 6337 6342 6348 6353 nand4_x0
xsubckt_1823_a3_x2 1 6027 0 6028 6029 6030 a3_x2
xsubckt_2193_mx2_x2 0 9073 1 7199 394 362 mx2_x2
xsubckt_2195_mx2_x2 0 9072 1 7199 393 361 mx2_x2
xsubckt_2197_mx2_x2 0 9071 1 7199 392 360 mx2_x2
xsubckt_9297_sff1_x4 1 1872 0 9164 675 sff1_x4
xsubckt_8846_sff1_x4 1 1872 0 9547 57 sff1_x4
xsubckt_8323_sff1_x4 1 1872 0 10062 214 sff1_x4
xsubckt_8286_buf_x1 1 0 1726 8723 buf_x1
xsubckt_8284_buf_x1 1 0 1728 8725 buf_x1
xsubckt_8282_buf_x1 1 0 1730 8727 buf_x1
xsubckt_6975_ao22_x2 0 8323 1 8324 7625 711 ao22_x2
xsubckt_6171_nand3_x0 1 0 2466 2469 2472 711 nand3_x0
xsubckt_5793_a3_x2 1 2831 0 7195 40 483 a3_x2
xsubckt_5389_nand2_x0 1 0 9516 3134 3147 nand2_x0
xsubckt_5195_ao22_x2 0 3313 1 3314 3315 3319 ao22_x2
xsubckt_4912_a2_x2 0 9576 1 3551 3552 a2_x2
xsubckt_4902_oa22_x2 0 3558 1 3562 1753 1752 oa22_x2
xsubckt_4873_nor3_x0 1 0 3580 3581 3605 3631 nor3_x0
xsubckt_4744_ao22_x2 0 3679 1 1792 3681 40 ao22_x2
xsubckt_4022_oa22_x2 0 3962 1 5595 5608 206 oa22_x2
xsubckt_3645_oa22_x2 0 4332 1 4399 4397 4396 oa22_x2
xsubckt_3554_a2_x2 0 4421 1 4422 4429 a2_x2
xsubckt_3514_a2_x2 0 4461 1 4462 4463 a2_x2
xsubckt_2745_nand2_x0 1 0 5215 7152 7280 nand2_x0
xsubckt_1287_a2_x2 0 6547 1 684 59 a2_x2
xsubckt_1648_a3_x2 1 6193 0 6353 7222 222 a3_x2
xsubckt_1716_nor4_x0 1 0 6125 527 601 605 604 nor4_x0
xsubckt_1863_nand2_x0 1 0 5991 6112 6224 nand2_x0
xsubckt_1953_nand2_x0 1 0 1922 5910 5914 nand2_x0
xsubckt_2388_oa22_x2 0 5566 1 7614 705 7219 oa22_x2
xsubckt_9654_sff1_x4 1 1872 0 8822 833 sff1_x4
xsubckt_9219_sff1_x4 1 1872 0 9240 531 sff1_x4
xsubckt_9131_sff1_x4 1 1872 0 9327 1153 sff1_x4
xsubckt_8754_sff1_x4 1 1872 0 9639 1263 sff1_x4
xsubckt_8397_sff1_x4 1 1872 0 10093 710 sff1_x4
xsubckt_8319_sff1_x4 1 1872 0 10066 219 sff1_x4
xsubckt_8288_buf_x1 1 0 1723 8721 buf_x1
xsubckt_7738_a2_x2 0 7828 1 3783 3900 a2_x2
xsubckt_7316_nand2_x0 1 0 8086 8138 591 nand2_x0
xsubckt_6849_a2_x2 0 9387 1 8447 8493 a2_x2
xsubckt_5970_mx2_x2 0 2662 1 710 1004 812 mx2_x2
xsubckt_5666_a2_x2 0 9450 1 2923 2924 a2_x2
xsubckt_5642_nand2_x0 1 0 2940 2943 1820 nand2_x0
xsubckt_5552_ao22_x2 0 3005 1 3010 1847 40 ao22_x2
xsubckt_5353_oa22_x2 0 3167 1 3204 3174 3169 oa22_x2
xsubckt_2655_nand2_x0 1 0 5304 5305 7179 nand2_x0
xsubckt_901_nand3_x0 1 0 6914 6915 6916 6917 nand3_x0
xsubckt_1523_xr2_x1 6318 0 1 196 226 xr2_x1
xsubckt_9127_sff1_x4 1 1872 0 9331 1157 sff1_x4
xsubckt_6360_ao22_x2 0 2281 1 7496 7625 712 ao22_x2
xsubckt_5972_mx2_x2 0 2660 1 708 2661 2663 mx2_x2
xsubckt_5784_oa22_x2 0 2839 1 7150 7137 2840 oa22_x2
xsubckt_5261_oa22_x2 0 3253 1 7680 3490 7167 oa22_x2
xsubckt_4443_mx3_x2 1 0 9821 3777 3897 1001 3863 3864 mx3_x2
xsubckt_4441_mx3_x2 1 0 9823 3777 3897 1003 3871 3872 mx3_x2
xsubckt_2495_ao22_x2 0 5461 1 5462 5465 703 ao22_x2
xsubckt_1322_oa22_x2 0 6514 1 6532 6527 6531 oa22_x2
xsubckt_1430_o2_x2 0 6411 1 179 208 o2_x2
xsubckt_1683_nand2_x0 1 0 6158 7233 210 nand2_x0
xsubckt_1769_nand3_x0 1 0 6076 6077 6078 6079 nand3_x0
xsubckt_1859_nand3_x0 1 0 5995 5996 5998 6221 nand3_x0
xsubckt_9562_sff1_x4 1 1872 0 8911 1209 sff1_x4
xsubckt_8662_sff1_x4 1 1872 0 9731 1425 sff1_x4
xsubckt_8013_mx3_x2 1 0 8838 7812 3896 847 3797 3798 mx3_x2
xsubckt_8011_mx3_x2 1 0 8840 7812 3896 850 3802 3804 mx3_x2
xsubckt_7691_ao22_x2 0 7840 1 7650 7954 7841 ao22_x2
xsubckt_7297_o2_x2 0 9295 1 8100 8102 o2_x2
xsubckt_6094_o2_x2 0 2541 1 1641 710 o2_x2
xsubckt_5419_o2_x2 0 9514 1 3106 3122 o2_x2
xsubckt_5268_nor2_x0 1 0 3246 3247 3248 nor2_x0
xsubckt_5180_nor2_x0 1 0 3327 3344 3511 nor2_x0
xsubckt_4449_mx3_x2 1 0 9815 3777 3896 1025 3844 3846 mx3_x2
xsubckt_4447_mx3_x2 1 0 9817 3777 3896 1027 3850 3852 mx3_x2
xsubckt_4445_mx3_x2 1 0 9819 3777 3897 1029 3856 3857 mx3_x2
xsubckt_3963_o3_x2 0 4019 1 4020 4173 5698 o3_x2
xsubckt_2613_o2_x2 0 5345 1 705 1422 o2_x2
xsubckt_2546_nor3_x0 1 0 5410 5411 5414 5417 nor3_x0
xsubckt_984_oa22_x2 0 6835 1 6859 6839 6840 oa22_x2
xsubckt_1487_xr2_x1 6354 0 1 191 221 xr2_x1
xsubckt_9558_sff1_x4 1 1872 0 8915 1214 sff1_x4
xsubckt_9470_sff1_x4 1 1872 0 8996 1191 sff1_x4
xsubckt_9035_sff1_x4 1 1872 0 9391 187 sff1_x4
xsubckt_7806_nxr2_x1 7824 1 0 7109 7682 nxr2_x1
xsubckt_6791_ao22_x2 0 8503 1 7625 951 8504 ao22_x2
xsubckt_5692_oa22_x2 0 2899 1 7358 7219 705 oa22_x2
xsubckt_5456_ao22_x2 0 3075 1 3079 1837 40 ao22_x2
xsubckt_5257_oa22_x2 0 3256 1 7087 3257 3259 oa22_x2
xsubckt_3816_o2_x2 0 4164 1 211 683 o2_x2
xsubckt_3026_oa22_x2 0 4940 1 5045 5001 4941 oa22_x2
xsubckt_2649_oa22_x2 0 5310 1 5595 5608 203 oa22_x2
xsubckt_906_oa22_x2 0 143 1 1740 6924 6910 oa22_x2
xsubckt_2117_nand2_x0 1 0 5766 417 308 nand2_x0
xsubckt_8658_sff1_x4 1 1872 0 9735 1071 sff1_x4
xsubckt_8570_sff1_x4 1 1872 0 9823 1003 sff1_x4
xsubckt_5614_oa22_x2 0 2960 1 1830 2967 1829 oa22_x2
xsubckt_3481_mx3_x2 1 0 4493 707 705 4494 1051 1179 mx3_x2
xsubckt_3003_mx2_x2 0 4962 1 705 1509 1349 mx2_x2
xsubckt_892_oa22_x2 0 6923 1 7041 7126 7632 oa22_x2
xsubckt_681_a4_x2 0 7116 1 1738 586 40 7790 a4_x2
xsubckt_9466_sff1_x4 1 1872 0 9000 1394 sff1_x4
xsubckt_8191_mx2_x2 0 8640 1 7799 3878 1229 mx2_x2
xsubckt_7835_mx3_x2 1 0 9006 7822 3896 1400 3820 3822 mx3_x2
xsubckt_7833_mx3_x2 1 0 9008 7822 3896 1402 3826 3828 mx3_x2
xsubckt_7831_mx3_x2 1 0 9010 7822 3896 1405 3832 3834 mx3_x2
xsubckt_7521_ao22_x2 0 7975 1 5797 7052 414 ao22_x2
xsubckt_7469_nand4_x0 1 0 7991 7992 7161 7697 40 nand4_x0
xsubckt_5617_nand4_x0 1 0 2958 2967 1828 1829 1830 nand4_x0
xsubckt_5533_nor2_x0 1 0 3019 3023 1853 nor2_x0
xsubckt_3899_nor2_x0 1 0 4082 4083 704 nor2_x0
xsubckt_3814_oa22_x2 0 4166 1 5595 5608 211 oa22_x2
xsubckt_3745_mx2_x2 0 4233 1 705 1495 1335 mx2_x2
xsubckt_3336_nand3_x0 1 0 4635 4636 5595 5608 nand3_x0
xsubckt_3133_ao22_x2 0 4835 1 5594 5609 7273 ao22_x2
xsubckt_714_nand2_x0 1 0 10104 7088 7090 nand2_x0
xsubckt_201_inv_x0 1 0 721 7590 inv_x0
xsubckt_2210_mx3_x2 1 0 5741 712 710 5742 956 1116 mx3_x2
xsubckt_9823_sff1_x4 1 1872 0 8653 1655 sff1_x4
xsubckt_9300_sff1_x4 1 1872 0 9161 690 sff1_x4
xsubckt_8566_sff1_x4 1 1872 0 9827 1009 sff1_x4
xsubckt_7839_mx3_x2 1 0 9002 7822 3896 1396 3808 3810 mx3_x2
xsubckt_7837_mx3_x2 1 0 9004 7822 3896 1398 3814 3816 mx3_x2
xsubckt_7793_mx3_x2 1 0 9044 7826 3896 1373 3832 3834 mx3_x2
xsubckt_7791_mx3_x2 1 0 9046 7826 3896 1375 3838 3840 mx3_x2
xsubckt_7708_mx2_x2 0 9157 1 7829 3890 1340 mx2_x2
xsubckt_7706_mx2_x2 0 9159 1 7829 3894 1352 mx2_x2
xsubckt_7517_ao22_x2 0 7978 1 5800 7042 414 ao22_x2
xsubckt_6496_oa22_x2 0 2148 1 7631 2153 711 oa22_x2
xsubckt_2914_oa22_x2 0 5050 1 5595 5608 228 oa22_x2
xsubckt_2609_mx3_x2 1 0 5349 707 705 5350 942 1102 mx3_x2
xsubckt_624_nand2_x0 1 0 7167 40 1742 nand2_x0
xsubckt_550_inv_x0 1 0 197 7241 inv_x0
xsubckt_207_inv_x0 1 0 1233 7584 inv_x0
xsubckt_205_inv_x0 1 0 1393 7586 inv_x0
xsubckt_203_inv_x0 1 0 1585 7588 inv_x0
xsubckt_2170_mx3_x2 1 0 462 7162 5754 213 91 123 mx3_x2
xsubckt_2233_ao22_x2 0 5718 1 5720 5732 708 ao22_x2
xsubckt_9819_sff1_x4 1 1872 0 8657 1659 sff1_x4
xsubckt_9374_sff1_x4 1 1872 0 9087 347 sff1_x4
xsubckt_8997_sff1_x4 1 1872 0 9428 503 sff1_x4
xsubckt_8923_sff1_x4 1 1872 0 9470 1835 sff1_x4
xsubckt_8400_sff1_x4 1 1872 0 298 43 sff1_x4
xsubckt_7797_mx3_x2 1 0 9040 7826 3896 1368 3820 3822 mx3_x2
xsubckt_7795_mx3_x2 1 0 9042 7826 3896 1370 3826 3828 mx3_x2
xsubckt_6133_mx3_x2 1 0 2503 712 710 2504 1542 1670 mx3_x2
xsubckt_5073_oa22_x2 0 3426 1 7680 3535 7167 oa22_x2
xsubckt_3564_ao22_x2 0 4411 1 4412 4421 7216 ao22_x2
xsubckt_3509_nand2_x0 1 0 4466 7217 1178 nand2_x0
xsubckt_2825_mx2_x2 0 5137 1 7217 7552 7554 mx2_x2
xsubckt_2823_mx2_x2 0 5139 1 7217 7544 7548 mx2_x2
xsubckt_2465_oa22_x2 0 5490 1 5491 5514 5585 oa22_x2
xsubckt_1003_nxr2_x1 6817 1 0 699 74 nxr2_x1
xsubckt_976_a2_x2 0 6843 1 700 75 a2_x2
xsubckt_556_inv_x0 1 0 179 7235 inv_x0
xsubckt_554_inv_x0 1 0 177 7237 inv_x0
xsubckt_552_inv_x0 1 0 175 7239 inv_x0
xsubckt_209_inv_x0 1 0 1105 7582 inv_x0
xsubckt_163_inv_x0 1 0 711 7628 inv_x0
xsubckt_161_inv_x0 1 0 1032 7630 inv_x0
xsubckt_1731_nand4_x0 1 0 6110 6113 6115 6117 7214 nand4_x0
xsubckt_1745_nand2_x0 1 0 6098 6116 6282 nand2_x0
xsubckt_2006_nand3_x0 1 0 5861 5863 6406 7788 nand3_x0
xsubckt_2172_mx3_x2 1 0 460 7162 5754 211 89 121 mx3_x2
xsubckt_2174_mx3_x2 1 0 458 7162 5754 209 87 119 mx3_x2
xsubckt_2176_mx3_x2 1 0 455 7162 5754 206 84 116 mx3_x2
xsubckt_2229_ao22_x2 0 5722 1 712 5726 5723 ao22_x2
xsubckt_9731_sff1_x4 1 1872 0 8745 755 sff1_x4
xsubckt_8919_sff1_x4 1 1872 0 9474 1840 sff1_x4
xsubckt_8831_sff1_x4 1 1872 0 9562 73 sff1_x4
xsubckt_8474_sff1_x4 1 1872 0 9919 1515 sff1_x4
xsubckt_7799_mx3_x2 1 0 9038 7826 3896 1366 3814 3816 mx3_x2
xsubckt_7661_oa22_x2 0 7864 1 644 7679 671 oa22_x2
xsubckt_7381_a4_x2 0 8037 1 8039 8080 7679 644 a4_x2
xsubckt_6871_mx3_x2 1 0 8425 712 710 8427 7402 7404 mx3_x2
xsubckt_6080_ao22_x2 0 2555 1 905 710 712 ao22_x2
xsubckt_5583_a4_x2 0 2983 1 2991 1838 1839 1840 a4_x2
xsubckt_5430_oa22_x2 0 3095 1 7102 3100 3096 oa22_x2
xsubckt_5348_a4_x2 0 3172 1 3174 3217 3224 3225 a4_x2
xsubckt_4895_ao22_x2 0 3563 1 1754 3564 40 ao22_x2
xsubckt_4018_a3_x2 1 3965 0 3966 5595 5608 a3_x2
xsubckt_3129_a3_x2 1 4838 0 4839 4841 4842 a3_x2
xsubckt_2781_mx2_x2 0 5180 1 707 5181 5182 mx2_x2
xsubckt_1042_oa22_x2 0 6779 1 1737 6788 6780 oa22_x2
xsubckt_630_o2_x2 0 7162 1 484 482 o2_x2
xsubckt_558_inv_x0 1 0 181 7233 inv_x0
xsubckt_169_inv_x0 1 0 1576 7622 inv_x0
xsubckt_167_inv_x0 1 0 1704 7624 inv_x0
xsubckt_165_inv_x0 1 0 808 7626 inv_x0
xsubckt_2436_mx2_x2 0 5519 1 705 1735 903 mx2_x2
xsubckt_9727_sff1_x4 1 1872 0 8749 759 sff1_x4
xsubckt_9282_sff1_x4 1 1872 0 9179 689 sff1_x4
xsubckt_9204_sff1_x4 1 1872 0 9254 655 sff1_x4
xsubckt_8382_sff1_x4 1 1872 0 10003 1565 sff1_x4
xsubckt_6484_mx3_x2 1 0 2160 712 710 2161 1598 734 mx3_x2
xsubckt_6482_mx3_x2 1 0 2162 712 710 2163 1534 1662 mx3_x2
xsubckt_6008_mx2_x2 0 2625 1 710 1451 1291 mx2_x2
xsubckt_6002_ao22_x2 0 2631 1 7556 7625 712 ao22_x2
xsubckt_5861_oa22_x2 0 2766 1 7600 710 7631 oa22_x2
xsubckt_5426_oa22_x2 0 3099 1 7680 3457 7167 oa22_x2
xsubckt_5250_a2_x2 0 3263 1 3492 650 a2_x2
xsubckt_4722_a3_x2 1 3695 0 3696 3707 3711 a3_x2
xsubckt_4078_a3_x2 1 3907 0 7209 520 521 a3_x2
xsubckt_3638_a3_x2 1 4338 0 4339 4340 4342 a3_x2
xsubckt_2789_mx2_x2 0 5172 1 705 747 1611 mx2_x2
xsubckt_904_o2_x2 0 6911 1 6912 6913 o2_x2
xsubckt_1922_oa22_x2 0 5938 1 5948 6191 6338 oa22_x2
xsubckt_2373_oa22_x2 0 5581 1 7615 705 7219 oa22_x2
xsubckt_2394_mx2_x2 0 5560 1 707 1736 1384 mx2_x2
xsubckt_2396_mx2_x2 0 5558 1 707 1640 1608 mx2_x2
xsubckt_9278_sff1_x4 1 1872 0 9183 685 sff1_x4
xsubckt_8827_sff1_x4 1 1872 0 9566 47 sff1_x4
xsubckt_8304_sff1_x4 1 1872 0 10081 204 sff1_x4
xsubckt_7616_a2_x2 0 9176 1 7902 7906 a2_x2
xsubckt_6473_a2_x2 0 2171 1 2172 7625 a2_x2
xsubckt_6046_nand2_x0 1 0 2588 2589 7631 nand2_x0
xsubckt_5820_mx2_x2 0 2806 1 7625 7626 7629 mx2_x2
xsubckt_5780_nor2_x0 1 0 2843 2844 7134 nor2_x0
xsubckt_5205_nor4_x0 1 0 3304 3344 3505 3508 3511 nor4_x0
xsubckt_5075_a2_x2 0 3424 1 3534 664 a2_x2
xsubckt_4782_a3_x2 1 3649 0 3650 3657 1786 a3_x2
xsubckt_4361_a2_x2 0 3784 1 519 520 a2_x2
xsubckt_3706_a2_x2 0 10062 1 4272 4334 a2_x2
xsubckt_3452_a2_x2 0 4522 1 217 689 a2_x2
xsubckt_1165_a2_x2 0 6662 1 6663 6671 a2_x2
xsubckt_834_xr2_x1 6978 0 1 679 54 xr2_x1
xsubckt_1207_nand2_x0 1 0 6623 688 63 nand2_x0
xsubckt_1586_a3_x2 1 6255 0 6286 6292 6296 a3_x2
xsubckt_1781_a3_x2 1 6065 0 6066 6067 6068 a3_x2
xsubckt_2094_a2_x2 0 5784 1 5785 5786 a2_x2
xsubckt_2369_oa22_x2 0 5585 1 7662 5592 5589 oa22_x2
xsubckt_2398_mx2_x2 0 5556 1 705 5557 5558 mx2_x2
xsubckt_9635_sff1_x4 1 1872 0 8838 847 sff1_x4
xsubckt_9190_sff1_x4 1 1872 0 9268 663 sff1_x4
xsubckt_9112_sff1_x4 1 1872 0 1915 1883 sff1_x4
xsubckt_8378_sff1_x4 1 1872 0 10007 1569 sff1_x4
xsubckt_8151_nand2_x0 1 0 7801 3787 3790 nand2_x0
xsubckt_7696_a2_x2 0 7836 1 647 600 a2_x2
xsubckt_5826_mx2_x2 0 2800 1 710 1384 872 mx2_x2
xsubckt_5824_mx2_x2 0 2802 1 710 1736 904 mx2_x2
xsubckt_5564_a2_x2 0 9478 1 2997 2998 a2_x2
xsubckt_5503_nand3_x0 1 0 3041 3047 1862 1863 nand3_x0
xsubckt_5369_nxr2_x1 3152 1 0 3177 3468 nxr2_x1
xsubckt_5042_mx2_x2 0 3453 1 5753 3798 115 mx2_x2
xsubckt_4909_a2_x2 0 9577 1 3553 3555 a2_x2
xsubckt_4850_a2_x2 0 9591 1 3598 3599 a2_x2
xsubckt_4675_a2_x2 0 3735 1 1745 1744 a2_x2
xsubckt_3626_oa22_x2 0 4350 1 1625 705 707 oa22_x2
xsubckt_2857_a2_x2 0 5106 1 199 671 a2_x2
xsubckt_2697_nor3_x0 1 0 5262 5263 5264 5267 nor3_x0
xsubckt_954_nand2_x0 1 0 6864 671 46 nand2_x0
xsubckt_1295_nand2_x0 1 0 6539 587 1754 nand2_x0
xsubckt_1694_a2_x2 0 6147 1 6148 6151 a2_x2
xsubckt_2087_nand2_x0 1 0 5790 445 308 nand2_x0
xsubckt_2430_nand2_x0 1 0 5525 5526 707 nand2_x0
xsubckt_9186_sff1_x4 1 1872 0 9272 589 sff1_x4
xsubckt_8735_sff1_x4 1 1872 0 9658 1284 sff1_x4
xsubckt_5591_nand3_x0 1 0 2977 2983 1835 1836 nand3_x0
xsubckt_5281_nxr2_x1 3234 1 0 3252 3486 nxr2_x1
xsubckt_5203_nxr2_x1 3306 1 0 3307 3310 nxr2_x1
xsubckt_4251_mx3_x2 1 0 9995 3795 3896 1556 3808 3810 mx3_x2
xsubckt_4014_nand2_x0 1 0 3969 7153 7258 nand2_x0
xsubckt_3902_nor2_x0 1 0 4079 4080 5585 nor2_x0
xsubckt_3177_oa22_x2 0 4791 1 4793 4796 7215 oa22_x2
xsubckt_2925_ao22_x2 0 5039 1 707 5040 706 ao22_x2
xsubckt_2645_nor2_x0 1 0 5313 5314 5603 nor2_x0
xsubckt_1113_o2_x2 0 6711 1 6712 6713 o2_x2
xcmpt_zero_100 1 0 14 zero_x1
xcmpt_zero_101 1 0 13 zero_x1
xcmpt_zero_102 1 0 12 zero_x1
xcmpt_zero_103 1 0 11 zero_x1
xcmpt_zero_104 1 0 10 zero_x1
xcmpt_zero_105 1 0 3 zero_x1
xsubckt_1381_oa22_x2 0 6458 1 6479 6474 6477 oa22_x2
xsubckt_1826_oa22_x2 0 6025 1 6246 6046 6026 oa22_x2
xsubckt_2426_nand3_x0 1 0 5529 5530 5532 706 nand3_x0
xsubckt_9543_sff1_x4 1 1872 0 8930 1201 sff1_x4
xsubckt_9108_sff1_x4 1 1872 0 1919 1887 sff1_x4
xsubckt_9020_sff1_x4 1 1872 0 9406 418 sff1_x4
xsubckt_8214_mx3_x2 1 0 8617 7800 3896 1235 3805 3807 mx3_x2
xsubckt_8212_mx3_x2 1 0 8619 7800 3896 1237 3811 3813 mx3_x2
xsubckt_8210_mx3_x2 1 0 8621 7800 3896 1239 3817 3819 mx3_x2
xsubckt_6736_nand2_x0 1 0 8557 8558 7613 nand2_x0
xsubckt_6115_nand3_x0 1 0 2520 2521 2530 709 nand3_x0
xsubckt_5854_nand2_x0 1 0 2773 2774 2777 nand2_x0
xsubckt_5441_ao22_x2 0 3085 1 644 3453 7168 ao22_x2
xsubckt_5277_nxr2_x1 3238 1 0 3487 665 nxr2_x1
xsubckt_5242_oa22_x2 0 3270 1 3287 3285 3286 oa22_x2
xsubckt_5084_ao22_x2 0 3415 1 7690 3421 3416 ao22_x2
xsubckt_4255_mx3_x2 1 0 9991 3795 3896 1551 3797 3798 mx3_x2
xsubckt_4253_mx3_x2 1 0 9993 3795 3896 1554 3802 3804 mx3_x2
xsubckt_4122_mx2_x2 0 3870 1 3896 3871 3872 mx2_x2
xsubckt_3128_nand3_x0 1 0 4839 4840 5011 5699 nand3_x0
xsubckt_965_oa22_x2 0 6853 1 525 6899 6854 oa22_x2
xsubckt_774_nand2_x0 1 0 7035 588 1807 nand2_x0
xsubckt_1377_oa22_x2 0 149 1 1740 6472 6462 oa22_x2
xsubckt_1407_o2_x2 0 6433 1 6434 6435 o2_x2
xsubckt_9094_sff1_x4 1 1872 0 1934 1902 sff1_x4
xsubckt_8643_sff1_x4 1 1872 0 9750 1088 sff1_x4
xsubckt_8216_mx3_x2 1 0 8615 7800 3896 1232 3799 3801 mx3_x2
xsubckt_8170_mx3_x2 1 0 8659 7802 3896 1662 3835 3837 mx3_x2
xsubckt_6646_nand2_x0 1 0 2001 2002 711 nand2_x0
xsubckt_6050_oa22_x2 0 2584 1 2585 2600 7620 oa22_x2
xsubckt_4997_mx3_x2 1 0 3487 5754 518 7769 7320 7321 mx3_x2
xsubckt_4993_mx3_x2 1 0 3490 5754 518 7768 7322 7323 mx3_x2
xsubckt_4473_mx2_x2 0 9793 1 3774 3878 1453 mx2_x2
xsubckt_4471_mx2_x2 0 9795 1 3774 3886 1457 mx2_x2
xsubckt_4126_mx2_x2 0 3867 1 518 78 1874 mx2_x2
xsubckt_3734_o2_x2 0 4244 1 705 919 o2_x2
xsubckt_3724_mx3_x2 1 0 4254 707 705 4255 1591 727 mx3_x2
xsubckt_3722_mx3_x2 1 0 4256 707 705 4257 1527 1655 mx3_x2
xsubckt_3579_o2_x2 0 4397 1 215 687 o2_x2
xsubckt_3085_oa22_x2 0 4882 1 4944 4940 4943 oa22_x2
xsubckt_85_inv_x0 1 0 1784 7706 inv_x0
xsubckt_83_inv_x0 1 0 1796 7708 inv_x0
xsubckt_81_inv_x0 1 0 1778 7710 inv_x0
xsubckt_2070_nand2_x0 1 0 5802 6114 6429 nand2_x0
xsubckt_9539_sff1_x4 1 1872 0 10099 1737 sff1_x4
xsubckt_9451_sff1_x4 1 1872 0 9015 1410 sff1_x4
xsubckt_9016_sff1_x4 1 1872 0 9410 434 sff1_x4
xsubckt_8639_sff1_x4 1 1872 0 9754 1092 sff1_x4
xsubckt_8176_mx3_x2 1 0 8653 7802 3896 1655 3817 3819 mx3_x2
xsubckt_8174_mx3_x2 1 0 8655 7802 3896 1657 3823 3825 mx3_x2
xsubckt_8172_mx3_x2 1 0 8657 7802 3896 1659 3829 3831 mx3_x2
xsubckt_7668_ao22_x2 0 9167 1 7862 7859 7860 ao22_x2
xsubckt_7388_nor2_x0 1 0 8030 365 370 nor2_x0
xsubckt_7348_nand2_x0 1 0 8061 8138 584 nand2_x0
xsubckt_3908_nand3_x0 1 0 4073 4074 4226 5699 nand3_x0
xsubckt_3204_mx2_x2 0 4765 1 707 4766 4767 mx2_x2
xsubckt_3202_mx2_x2 0 4767 1 705 1377 865 mx2_x2
xsubckt_3200_mx2_x2 0 4769 1 705 1025 833 mx2_x2
xsubckt_2687_nand2_x0 1 0 5272 5274 7215 nand2_x0
xsubckt_2509_nand2_x0 1 0 5447 5448 5449 nand2_x0
xsubckt_873_oa22_x2 0 6941 1 7041 7126 7634 oa22_x2
xsubckt_89_inv_x0 1 0 40 7702 inv_x0
xsubckt_87_inv_x0 1 0 1871 7704 inv_x0
xsubckt_2306_ao22_x2 0 5647 1 5648 5649 7620 ao22_x2
xsubckt_9447_sff1_x4 1 1872 0 9019 1414 sff1_x4
xsubckt_8551_sff1_x4 1 1872 0 9842 1499 sff1_x4
xsubckt_8178_mx3_x2 1 0 8651 7802 3896 1653 3811 3813 mx3_x2
xsubckt_7580_ao22_x2 0 7930 1 607 594 360 ao22_x2
xsubckt_7510_mx2_x2 0 9200 1 7985 421 316 mx2_x2
xsubckt_7258_nand2_x0 1 0 8126 8127 8135 nand2_x0
xsubckt_5669_oa22_x2 0 2920 1 1813 2927 1812 oa22_x2
xsubckt_5146_oa22_x2 0 3358 1 3359 3365 3368 oa22_x2
xsubckt_5107_nxr2_x1 3394 1 0 3407 3528 nxr2_x1
xsubckt_4788_nand3_x0 1 0 3644 3646 3657 1786 nand3_x0
xsubckt_3940_mx2_x2 0 4042 1 7217 7388 7389 mx2_x2
xsubckt_3208_mx2_x2 0 4761 1 705 1441 1281 mx2_x2
xsubckt_3206_mx2_x2 0 4763 1 705 1505 1345 mx2_x2
xsubckt_941_a3_x2 1 6876 0 6877 6878 7045 a3_x2
xsubckt_400_inv_x0 1 0 1044 7391 inv_x0
xsubckt_9882_sff1_x4 1 1872 0 8594 1629 sff1_x4
xsubckt_9804_sff1_x4 1 1872 0 8672 1645 sff1_x4
xsubckt_8982_sff1_x4 1 1872 0 9443 489 sff1_x4
xsubckt_8547_sff1_x4 1 1872 0 9846 1504 sff1_x4
xsubckt_7992_mx3_x2 1 0 8859 7812 3897 870 3859 3860 mx3_x2
xsubckt_7990_mx3_x2 1 0 8861 7812 3897 842 3867 3868 mx3_x2
xsubckt_7576_ao22_x2 0 7933 1 607 594 359 ao22_x2
xsubckt_7516_mx2_x2 0 7979 1 2857 7981 305 mx2_x2
xsubckt_7514_mx2_x2 0 7980 1 2857 7981 306 mx2_x2
xsubckt_6893_nand3_x0 1 0 8403 8404 8428 2729 nand3_x0
xsubckt_6108_nand2_x0 1 0 2527 2528 7628 nand2_x0
xsubckt_5588_nor2_x0 1 0 2979 2983 1836 nor2_x0
xsubckt_5581_oa22_x2 0 2984 1 1840 2991 1839 oa22_x2
xsubckt_5345_ao22_x2 0 3175 1 600 3176 644 ao22_x2
xsubckt_5226_nand2_x0 1 0 3285 3499 7662 nand2_x0
xsubckt_3948_mx2_x2 0 4034 1 705 1427 1267 mx2_x2
xsubckt_3559_mx2_x2 0 4416 1 705 1402 1242 mx2_x2
xsubckt_3557_mx2_x2 0 4418 1 706 4419 4420 mx2_x2
xsubckt_3555_mx2_x2 0 4420 1 705 1434 1274 mx2_x2
xsubckt_3552_nand2_x0 1 0 4423 4424 7219 nand2_x0
xsubckt_3299_nand2_x0 1 0 4672 4673 7179 nand2_x0
xsubckt_3188_ao22_x2 0 4780 1 7180 4828 4781 ao22_x2
xsubckt_1115_oa22_x2 0 164 1 1740 6726 6710 oa22_x2
xsubckt_402_inv_x0 1 0 1491 7389 inv_x0
xsubckt_404_inv_x0 1 0 1171 7387 inv_x0
xsubckt_406_inv_x0 1 0 848 7385 inv_x0
xsubckt_1447_nand2_x0 1 0 6394 181 210 nand2_x0
xsubckt_2292_ao22_x2 0 5660 1 529 5662 5661 ao22_x2
xsubckt_9878_sff1_x4 1 1872 0 8598 1633 sff1_x4
xsubckt_9790_sff1_x4 1 1872 0 8686 1688 sff1_x4
xsubckt_9355_sff1_x4 1 1872 0 9106 1050 sff1_x4
xsubckt_8904_sff1_x4 1 1872 0 9489 1856 sff1_x4
xsubckt_7998_mx3_x2 1 0 8853 7812 3896 864 3841 3843 mx3_x2
xsubckt_7996_mx3_x2 1 0 8855 7812 3896 866 3847 3849 mx3_x2
xsubckt_7994_mx3_x2 1 0 8857 7812 3896 868 3853 3855 mx3_x2
xsubckt_6723_mx3_x2 1 0 8570 712 710 8571 7430 7433 mx3_x2
xsubckt_6676_ao22_x2 0 1972 1 1973 1975 1976 ao22_x2
xsubckt_6153_ao22_x2 0 2483 1 534 532 700 ao22_x2
xsubckt_5040_a3_x2 1 3455 0 40 52 7780 a3_x2
xsubckt_5020_a3_x2 1 3470 0 40 58 7780 a3_x2
xsubckt_5000_a3_x2 1 3485 0 40 63 7780 a3_x2
xsubckt_4115_nxr2_x1 3876 1 0 3881 7726 nxr2_x1
xsubckt_2762_mx3_x2 1 0 5199 707 705 5200 939 1099 mx3_x2
xsubckt_980_ao22_x2 0 6839 1 6888 6862 6864 ao22_x2
xsubckt_902_ao22_x2 0 6913 1 6914 6918 7038 ao22_x2
xsubckt_699_a2_x2 0 7102 1 644 600 a2_x2
xsubckt_648_nor4_x0 1 0 7147 585 586 592 609 nor4_x0
xsubckt_360_inv_x0 1 0 1560 7431 inv_x0
xsubckt_362_inv_x0 1 0 1496 7429 inv_x0
xsubckt_364_inv_x0 1 0 1400 7427 inv_x0
xsubckt_408_inv_x0 1 0 1424 7383 inv_x0
xsubckt_1267_nand2_x0 1 0 6566 685 60 nand2_x0
xsubckt_2240_mx2_x2 0 5711 1 710 764 1628 mx2_x2
xsubckt_2242_mx2_x2 0 5709 1 710 1724 892 mx2_x2
xsubckt_2402_nand2_x0 1 0 5552 5553 7219 nand2_x0
xsubckt_9712_sff1_x4 1 1872 0 8764 745 sff1_x4
xsubckt_8978_sff1_x4 1 1872 0 146 83 sff1_x4
xsubckt_8890_sff1_x4 1 1872 0 9503 1809 sff1_x4
xsubckt_8455_sff1_x4 1 1872 0 9938 731 sff1_x4
xsubckt_7478_mx2_x2 0 9232 1 7990 7984 343 mx2_x2
xsubckt_7474_mx2_x2 0 9233 1 7990 7987 344 mx2_x2
xsubckt_7237_nand3_x0 1 0 8143 9090 8152 9089 nand3_x0
xsubckt_7049_ao22_x2 0 8251 1 1456 710 712 ao22_x2
xsubckt_6510_ao22_x2 0 2134 1 2139 2137 2135 ao22_x2
xsubckt_5610_ao22_x2 0 2963 1 2967 1830 40 ao22_x2
xsubckt_5418_nor2_x0 1 0 3106 3107 3121 nor2_x0
xsubckt_5334_a3_x2 1 3185 0 3212 3474 3477 a3_x2
xsubckt_5046_nand2_x0 1 0 3450 3544 648 nand2_x0
xsubckt_4004_a2_x2 0 3979 1 3980 3985 a2_x2
xsubckt_3769_xr2_x1 4210 0 1 212 684 xr2_x1
xsubckt_836_nand2_x0 1 0 6976 6977 1740 nand2_x0
xsubckt_366_inv_x0 1 0 1304 7425 inv_x0
xsubckt_368_inv_x0 1 0 952 7423 inv_x0
xsubckt_1177_nand2_x0 1 0 6651 588 1796 nand2_x0
xsubckt_2377_mx3_x2 1 0 5577 707 705 5578 1320 1480 mx3_x2
xsubckt_9786_sff1_x4 1 1872 0 8690 1693 sff1_x4
xsubckt_9263_sff1_x4 1 1872 0 9198 305 sff1_x4
xsubckt_8812_sff1_x4 1 1872 0 9581 1755 sff1_x4
xsubckt_7398_a4_x2 0 8022 1 8023 8029 8032 8036 a4_x2
xsubckt_6886_nand2_x0 1 0 8410 8411 712 nand2_x0
xsubckt_6749_nor2_x0 1 0 8544 8545 711 nor2_x0
xsubckt_6311_a2_x2 0 2329 1 7500 710 a2_x2
xsubckt_6209_mx2_x2 0 2429 1 712 996 964 mx2_x2
xsubckt_6161_mx2_x2 0 2476 1 710 1477 1317 mx2_x2
xsubckt_6001_nand2_x0 1 0 2632 1387 7625 nand2_x0
xsubckt_5853_nor2_x0 1 0 2774 2780 7628 nor2_x0
xsubckt_5801_mx3_x2 1 0 2825 712 710 2826 1256 1416 mx3_x2
xsubckt_5021_mx3_x2 1 0 3469 5754 518 7775 7308 7309 mx3_x2
xsubckt_3135_a2_x2 0 4833 1 224 696 a2_x2
xsubckt_3087_a3_x2 1 4880 0 4883 4940 4942 a3_x2
xsubckt_3014_nand2_x0 1 0 4951 7153 7277 nand2_x0
xsubckt_2986_mx2_x2 0 4979 1 706 1061 965 mx2_x2
xsubckt_2984_mx2_x2 0 4981 1 706 1189 1125 mx2_x2
xsubckt_1097_oa22_x2 0 6727 1 6753 6748 6730 oa22_x2
xsubckt_1063_a2_x2 0 6759 1 225 1739 a2_x2
xsubckt_1023_a2_x2 0 6798 1 698 73 a2_x2
xsubckt_746_nand2_x0 1 0 7059 7060 7192 nand2_x0
xsubckt_667_o2_x2 0 7128 1 483 481 o2_x2
xsubckt_1190_a3_x2 1 6639 0 6659 6675 6677 a3_x2
xsubckt_1415_nxr2_x1 6426 1 0 177 205 nxr2_x1
xsubckt_1493_nxr2_x1 6348 1 0 192 222 nxr2_x1
xsubckt_2132_nand2_x0 1 0 5761 7044 183 nand2_x0
xsubckt_9708_sff1_x4 1 1872 0 8768 749 sff1_x4
xsubckt_9620_sff1_x4 1 1872 0 8853 864 sff1_x4
xsubckt_8886_sff1_x4 1 1872 0 9507 1837 sff1_x4
xsubckt_8808_sff1_x4 1 1872 0 9585 1759 sff1_x4
xsubckt_8363_sff1_x4 1 1872 0 10022 1576 sff1_x4
xsubckt_8293_buf_x1 1 0 1718 8716 buf_x1
xsubckt_8291_buf_x1 1 0 1720 8718 buf_x1
xsubckt_7392_ao22_x2 0 8027 1 645 7680 589 ao22_x2
xsubckt_7359_a2_x2 0 8053 1 8060 8130 a2_x2
xsubckt_6949_mx2_x2 0 8349 1 710 8350 8351 mx2_x2
xsubckt_6947_mx2_x2 0 8351 1 712 979 947 mx2_x2
xsubckt_6556_mx2_x2 0 2089 1 7625 7471 7473 mx2_x2
xsubckt_6351_a2_x2 0 2290 1 2291 708 a2_x2
xsubckt_6163_mx2_x2 0 2474 1 712 2475 2476 mx2_x2
xsubckt_5736_nand2_x0 1 0 2856 2858 2859 nand2_x0
xsubckt_5648_a3_x2 1 9455 0 2936 2937 40 a3_x2
xsubckt_5025_mx3_x2 1 0 3466 5754 518 7776 7306 7307 mx3_x2
xsubckt_4914_a3_x2 1 3549 0 3554 1749 1748 a3_x2
xsubckt_4084_a2_x2 0 3901 1 3902 7168 a2_x2
xsubckt_4069_nor2_x0 1 0 3915 3916 3941 nor2_x0
xsubckt_3685_oa22_x2 0 4292 1 4293 4298 703 oa22_x2
xsubckt_3576_a3_x2 1 4400 0 4469 4470 4473 a3_x2
xsubckt_3441_nand3_x0 1 0 4532 4533 4686 7104 nand3_x0
xsubckt_3350_a2_x2 0 4622 1 4623 7215 a2_x2
xsubckt_2862_a3_x2 1 5101 0 5105 5149 5150 a3_x2
xsubckt_1160_nand2_x0 1 0 6667 587 1761 nand2_x0
xsubckt_785_mx2_x2 0 7025 1 229 378 391 mx2_x2
xsubckt_1250_nand2_x0 1 0 6582 686 61 nand2_x0
xsubckt_1317_a2_x2 0 6518 1 211 1739 a2_x2
xsubckt_1512_a2_x2 0 6329 1 193 223 a2_x2
xsubckt_1977_oa22_x2 0 1920 1 6111 5888 5894 oa22_x2
xsubckt_2246_a2_x2 0 5705 1 5706 7613 a2_x2
xsubckt_2266_a2_x2 0 5686 1 5687 7625 a2_x2
xsubckt_9694_sff1_x4 1 1872 0 8782 792 sff1_x4
xsubckt_9259_sff1_x4 1 1872 0 9202 319 sff1_x4
xsubckt_9171_sff1_x4 1 1872 0 9287 573 sff1_x4
xsubckt_8720_sff1_x4 1 1872 0 9673 1106 sff1_x4
xsubckt_8359_sff1_x4 1 1872 0 10026 1587 sff1_x4
xsubckt_8299_buf_x1 1 0 1711 8710 buf_x1
xsubckt_8297_buf_x1 1 0 1714 8712 buf_x1
xsubckt_8295_buf_x1 1 0 1716 8714 buf_x1
xsubckt_6528_nand2_x0 1 0 2117 2118 7631 nand2_x0
xsubckt_6169_mx2_x2 0 2468 1 7625 7528 7530 mx2_x2
xsubckt_5723_o4_x2 0 2868 1 206 41 43 42 o4_x2
xsubckt_5157_ao22_x2 0 3348 1 7086 3349 3351 ao22_x2
xsubckt_5029_mx3_x2 1 0 3463 5754 518 7777 7304 7305 mx3_x2
xsubckt_4847_a2_x2 0 9592 1 3600 3602 a2_x2
xsubckt_4799_a3_x2 1 9603 0 3637 3638 40 a3_x2
xsubckt_4779_a3_x2 1 9608 0 3652 3654 40 a3_x2
xsubckt_4750_nand4_x0 1 0 3674 3675 3688 3701 1799 nand4_x0
xsubckt_3918_a2_x2 0 4064 1 209 681 a2_x2
xsubckt_3489_a2_x2 0 4485 1 4487 7215 a2_x2
xsubckt_3449_a2_x2 0 10066 1 4525 4568 a2_x2
xsubckt_3361_ao22_x2 0 4611 1 7488 705 707 ao22_x2
xsubckt_2785_oa22_x2 0 5176 1 707 5177 704 oa22_x2
xsubckt_2659_nand2_x0 1 0 5300 5301 7218 nand2_x0
xsubckt_1070_nand2_x0 1 0 6753 696 71 nand2_x0
xsubckt_1530_xr2_x1 6311 0 1 198 228 xr2_x1
xsubckt_1572_a2_x2 0 6269 1 7251 207 a2_x2
xsubckt_1867_nand2_x0 1 0 5988 6222 6319 nand2_x0
xsubckt_1973_a3_x2 1 5891 0 5906 6369 6372 a3_x2
xsubckt_9616_sff1_x4 1 1872 0 8857 868 sff1_x4
xsubckt_8794_sff1_x4 1 1872 0 9599 1775 sff1_x4
xsubckt_8716_sff1_x4 1 1872 0 9677 1110 sff1_x4
xsubckt_6348_nand2_x0 1 0 2293 2294 2295 nand2_x0
xsubckt_6289_oa22_x2 0 2350 1 2351 2364 2728 oa22_x2
xsubckt_5466_nand2_x0 1 0 3068 3071 1810 nand2_x0
xsubckt_4450_mx3_x2 1 0 9814 3777 3896 1024 3841 3843 mx3_x2
xsubckt_3968_nand3_x0 1 0 4014 4015 5595 5608 nand3_x0
xsubckt_3704_nand2_x0 1 0 4273 4274 4281 nand2_x0
xsubckt_3070_oa22_x2 0 4896 1 4897 4902 7215 oa22_x2
xsubckt_2908_nand3_x0 1 0 5055 5056 5214 5699 nand3_x0
xsubckt_2654_nxr2_x1 5305 1 0 5306 5309 nxr2_x1
xsubckt_911_nxr2_x1 6905 1 0 6906 6909 nxr2_x1
xsubckt_1500_o2_x2 0 6341 1 190 220 o2_x2
xsubckt_1536_xr2_x1 6305 0 1 175 199 xr2_x1
xsubckt_1687_nand2_x0 1 0 6154 7235 208 nand2_x0
xsubckt_2214_o2_x2 0 5737 1 5738 712 o2_x2
xsubckt_9524_sff1_x4 1 1872 0 8942 952 sff1_x4
xsubckt_9167_sff1_x4 1 1872 0 9291 580 sff1_x4
xsubckt_7657_nand3_x0 1 0 7867 7869 7679 644 nand3_x0
xsubckt_6511_nand2_x0 1 0 2133 2134 7628 nand2_x0
xsubckt_5452_nand4_x0 1 0 3078 1848 1859 1870 1871 nand4_x0
xsubckt_4456_mx3_x2 1 0 9808 3777 3896 1017 3823 3825 mx3_x2
xsubckt_4454_mx3_x2 1 0 9810 3777 3896 1019 3829 3831 mx3_x2
xsubckt_4452_mx3_x2 1 0 9812 3777 3896 1022 3835 3837 mx3_x2
xsubckt_3714_ao22_x2 0 4264 1 4332 4329 4330 ao22_x2
xsubckt_3027_nxr2_x1 4939 1 0 4940 4942 nxr2_x1
xsubckt_725_nand3_x0 1 0 7078 7080 7125 7130 nand3_x0
xsubckt_1419_nand2_x0 1 0 6422 178 206 nand2_x0
xsubckt_1492_xr2_x1 6349 0 1 192 222 xr2_x1
xsubckt_1520_o2_x2 0 6321 1 196 226 o2_x2
xsubckt_1583_nand4_x0 1 0 6258 6262 6268 6270 6286 nand4_x0
xsubckt_1726_nor2_x0 1 0 6115 608 609 nor2_x0
xsubckt_9598_sff1_x4 1 1872 0 8875 917 sff1_x4
xsubckt_9075_sff1_x4 1 1872 0 9351 1302 sff1_x4
xsubckt_9001_sff1_x4 1 1872 0 9424 499 sff1_x4
xsubckt_8624_sff1_x4 1 1872 0 9769 1458 sff1_x4
xsubckt_8026_mx3_x2 1 0 8827 7810 3897 838 3859 3860 mx3_x2
xsubckt_8024_mx3_x2 1 0 8829 7810 3897 810 3867 3868 mx3_x2
xsubckt_7373_nor2_x0 1 0 8043 8044 8075 nor2_x0
xsubckt_7130_ao22_x2 0 8173 1 1740 7780 40 ao22_x2
xsubckt_6685_nand3_x0 1 0 1963 1964 1971 7613 nand3_x0
xsubckt_6168_nand2_x0 1 0 2469 2470 2471 nand2_x0
xsubckt_6078_nand2_x0 1 0 2557 2558 7631 nand2_x0
xsubckt_4688_ao22_x2 0 3725 1 1803 3726 40 ao22_x2
xsubckt_4458_mx3_x2 1 0 9806 3777 3896 1015 3817 3819 mx3_x2
xsubckt_4329_mx2_x2 0 9926 1 3785 3894 1544 mx2_x2
xsubckt_3698_nand3_x0 1 0 4279 4280 4479 5699 nand3_x0
xsubckt_3077_nand4_x0 1 0 4889 5604 532 7689 73 nand4_x0
xsubckt_2743_o2_x2 0 5217 1 5218 5230 o2_x2
xsubckt_865_nor2_x0 1 0 6948 6949 6955 nor2_x0
xsubckt_1358_oa22_x2 0 150 1 1740 6490 6480 oa22_x2
xsubckt_1498_xr2_x1 6343 0 1 189 219 xr2_x1
xsubckt_1793_oa22_x2 0 6055 1 6258 6259 6293 oa22_x2
xsubckt_1814_o2_x2 0 6036 1 6037 7788 o2_x2
xsubckt_9432_sff1_x4 1 1872 0 9034 1362 sff1_x4
xsubckt_8698_sff1_x4 1 1872 0 9695 1099 sff1_x4
xsubckt_8028_mx3_x2 1 0 8825 7810 3896 836 3853 3855 mx3_x2
xsubckt_6987_o2_x2 0 8311 1 8312 7134 o2_x2
xsubckt_6753_ao22_x2 0 9389 1 8541 8543 1944 ao22_x2
xsubckt_5219_oa22_x2 0 3291 1 3293 3294 7690 oa22_x2
xsubckt_5166_nxr2_x1 3340 1 0 3514 649 nxr2_x1
xsubckt_3925_mx3_x2 1 0 4057 707 705 4058 851 1363 mx3_x2
xsubckt_3145_mx3_x2 1 0 4823 707 705 4824 1058 1186 mx3_x2
xsubckt_2689_oa22_x2 0 5270 1 5271 5272 5585 oa22_x2
xsubckt_1402_nand2_x0 1 0 6438 588 1782 nand2_x0
xsubckt_8532_sff1_x4 1 1872 0 9861 1511 sff1_x4
xsubckt_7842_mx3_x2 1 0 8999 7822 3896 1392 3799 3801 mx3_x2
xsubckt_7840_mx3_x2 1 0 9001 7822 3896 1395 3805 3807 mx3_x2
xsubckt_6226_ao22_x2 0 2412 1 7625 1604 2413 ao22_x2
xsubckt_3164_nand2_x0 1 0 4804 4805 4806 nand2_x0
xsubckt_3149_mx3_x2 1 0 4819 707 705 4820 1538 1666 mx3_x2
xsubckt_2801_nand3_x0 1 0 5160 5161 5318 7104 nand3_x0
xsubckt_2470_nxr2_x1 5485 1 0 701 229 nxr2_x1
xsubckt_1059_nand2_x0 1 0 6763 588 1802 nand2_x0
xsubckt_718_nand2_x0 1 0 7084 7100 7690 nand2_x0
xsubckt_1312_nand2_x0 1 0 6523 588 1788 nand2_x0
xsubckt_9863_sff1_x4 1 1872 0 8613 1640 sff1_x4
xsubckt_9428_sff1_x4 1 1872 0 9038 1366 sff1_x4
xsubckt_9340_sff1_x4 1 1872 0 9121 1036 sff1_x4
xsubckt_7715_mx2_x2 0 9150 1 7829 3862 1321 mx2_x2
xsubckt_7713_mx2_x2 0 9152 1 7829 3870 1323 mx2_x2
xsubckt_7711_mx2_x2 0 9154 1 7829 3878 1325 mx2_x2
xsubckt_5849_ao22_x2 0 2778 1 935 710 712 ao22_x2
xsubckt_5326_ao22_x2 0 3192 1 3198 3196 3193 ao22_x2
xsubckt_2989_nand2_x0 1 0 4976 4977 4982 nand2_x0
xsubckt_2796_ao22_x2 0 5165 1 5166 703 7218 ao22_x2
xsubckt_1174_oa22_x2 0 6654 1 398 7044 6880 oa22_x2
xsubckt_1135_nxr2_x1 6691 1 0 693 68 nxr2_x1
xsubckt_958_a3_x2 1 6860 0 6863 6886 6887 a3_x2
xsubckt_732_a2_x2 0 7071 1 7675 1741 a2_x2
xsubckt_214_inv_x0 1 0 1486 7577 inv_x0
xsubckt_212_inv_x0 1 0 910 7579 inv_x0
xsubckt_210_inv_x0 1 0 977 7581 inv_x0
xsubckt_8963_sff1_x4 1 1872 0 163 100 sff1_x4
xsubckt_8528_sff1_x4 1 1872 0 9865 978 sff1_x4
xsubckt_8440_sff1_x4 1 1872 0 9953 717 sff1_x4
xsubckt_6657_ao22_x2 0 1990 1 534 532 688 ao22_x2
xsubckt_6134_ao22_x2 0 2502 1 7620 2503 7613 ao22_x2
xsubckt_4861_ao22_x2 0 3589 1 1763 3591 40 ao22_x2
xsubckt_3762_oa22_x2 0 4217 1 5595 5608 212 oa22_x2
xsubckt_3081_ao22_x2 0 10073 1 4886 4938 4945 ao22_x2
xsubckt_2834_mx2_x2 0 5128 1 7219 5129 5130 mx2_x2
xsubckt_2832_mx2_x2 0 5130 1 705 1482 1322 mx2_x2
xsubckt_2830_mx2_x2 0 5132 1 705 1194 1066 mx2_x2
xsubckt_961_ao22_x2 0 6857 1 6885 6861 6858 ao22_x2
xsubckt_632_o3_x2 0 7160 1 484 482 483 o3_x2
xsubckt_563_inv_x0 1 0 186 7228 inv_x0
xsubckt_561_inv_x0 1 0 184 7230 inv_x0
xsubckt_170_inv_x0 1 0 1544 7621 inv_x0
xsubckt_216_inv_x0 1 0 1326 7575 inv_x0
xsubckt_218_inv_x0 1 0 676 7573 inv_x0
xsubckt_1373_ao22_x2 0 6465 1 6466 6470 7038 ao22_x2
xsubckt_9859_sff1_x4 1 1872 0 8617 1235 sff1_x4
xsubckt_9771_sff1_x4 1 1872 0 8705 1678 sff1_x4
xsubckt_9336_sff1_x4 1 1872 0 9125 1052 sff1_x4
xsubckt_8959_sff1_x4 1 1872 0 167 104 sff1_x4
xsubckt_8436_sff1_x4 1 1872 0 9957 743 sff1_x4
xsubckt_7366_nand4_x0 1 0 8048 8051 8063 8078 8140 nand4_x0
xsubckt_7296_a4_x2 0 8100 1 8136 531 7679 644 a4_x2
xsubckt_6533_mx3_x2 1 0 2112 712 710 2113 7477 7479 mx3_x2
xsubckt_6498_nand2_x0 1 0 2146 2147 2151 nand2_x0
xsubckt_6013_mx2_x2 0 2620 1 7631 2621 2622 mx2_x2
xsubckt_6011_mx2_x2 0 2622 1 710 1707 875 mx2_x2
xsubckt_5212_a3_x2 1 3298 0 3321 3501 3504 a3_x2
xsubckt_5035_oa22_x2 0 9545 1 7168 3459 3461 oa22_x2
xsubckt_4646_nand2_x0 1 0 3757 3760 1795 nand2_x0
xsubckt_2838_mx2_x2 0 5124 1 7219 5125 5126 mx2_x2
xsubckt_2836_mx2_x2 0 5126 1 705 1706 874 mx2_x2
xsubckt_2790_mx2_x2 0 5171 1 705 715 1579 mx2_x2
xsubckt_2576_mx3_x2 1 0 5381 7216 707 5384 5382 5383 mx3_x2
xsubckt_1128_nand3_x0 1 0 6697 6698 6699 6700 nand3_x0
xsubckt_1038_nand3_x0 1 0 6783 6784 6785 6786 nand3_x0
xsubckt_569_inv_x0 1 0 192 7222 inv_x0
xsubckt_567_inv_x0 1 0 190 7224 inv_x0
xsubckt_565_inv_x0 1 0 188 7226 inv_x0
xsubckt_176_inv_x0 1 0 1064 7615 inv_x0
xsubckt_174_inv_x0 1 0 1352 7617 inv_x0
xsubckt_172_inv_x0 1 0 1512 7619 inv_x0
xsubckt_1659_nand2_x0 1 0 6182 6185 6189 nand2_x0
xsubckt_2054_mx2_x2 0 5817 1 7788 5818 5820 mx2_x2
xsubckt_2441_nand3_x0 1 0 5514 5515 5523 7215 nand3_x0
xsubckt_2443_mx2_x2 0 5512 1 705 1447 1287 mx2_x2
xsubckt_2447_mx2_x2 0 5508 1 705 1511 1351 mx2_x2
xsubckt_9767_sff1_x4 1 1872 0 8709 1704 sff1_x4
xsubckt_8871_sff1_x4 1 1872 0 9522 126 sff1_x4
xsubckt_7623_oa22_x2 0 7896 1 644 7679 695 oa22_x2
xsubckt_7543_nand2_x0 1 0 9191 7960 7961 nand2_x0
xsubckt_6406_mx2_x2 0 2236 1 710 768 1632 mx2_x2
xsubckt_6366_oa22_x2 0 2275 1 2276 2283 709 oa22_x2
xsubckt_6015_mx2_x2 0 2618 1 710 1195 1067 mx2_x2
xsubckt_5546_a3_x2 1 3010 0 3015 1849 1850 a3_x2
xsubckt_5125_a2_x2 0 3378 1 3522 660 a2_x2
xsubckt_4857_ao22_x2 0 3592 1 1764 3593 40 ao22_x2
xsubckt_3674_nand2_x0 1 0 4303 4304 4309 nand2_x0
xsubckt_2882_nand2_x0 1 0 5081 5082 5085 nand2_x0
xsubckt_2794_mx2_x2 0 5167 1 707 5168 5169 mx2_x2
xsubckt_2792_mx2_x2 0 5169 1 705 1355 843 mx2_x2
xsubckt_178_inv_x0 1 0 708 7613 inv_x0
xsubckt_1201_nand3_x0 1 0 6628 6629 6630 6631 nand3_x0
xsubckt_1410_a2_x2 0 6431 1 7237 205 a2_x2
xsubckt_1811_a3_x2 1 6038 0 6039 6040 6041 a3_x2
xsubckt_1822_nand2_x0 1 0 6028 6112 6308 nand2_x0
xsubckt_2104_a2_x2 0 5776 1 5777 5778 a2_x2
xsubckt_9601_sff1_x4 1 1872 0 8872 914 sff1_x4
xsubckt_9244_sff1_x4 1 1872 0 9217 335 sff1_x4
xsubckt_8867_sff1_x4 1 1872 0 9526 131 sff1_x4
xsubckt_8344_sff1_x4 1 1872 0 10041 1603 sff1_x4
xsubckt_7539_nand3_x0 1 0 7962 7168 655 7791 nand3_x0
xsubckt_7174_oa22_x2 0 8163 1 1737 7193 8164 oa22_x2
xsubckt_6759_mx2_x2 0 8535 1 712 759 727 mx2_x2
xsubckt_6757_mx2_x2 0 8537 1 710 8538 8539 mx2_x2
xsubckt_6755_mx2_x2 0 8539 1 712 1559 1527 mx2_x2
xsubckt_6747_nand3_x0 1 0 8546 8547 8548 708 nand3_x0
xsubckt_6543_a2_x2 0 2102 1 7474 710 a2_x2
xsubckt_5665_ao22_x2 0 2923 1 2927 1813 40 ao22_x2
xsubckt_5380_a2_x2 0 3142 1 3465 665 a2_x2
xsubckt_5335_nxr2_x1 3184 1 0 3195 3474 nxr2_x1
xsubckt_5165_a2_x2 0 3341 1 3513 649 a2_x2
xsubckt_5142_ao22_x2 0 3362 1 3379 3378 3377 ao22_x2
xsubckt_4852_a3_x2 1 3596 0 3601 1766 1765 a3_x2
xsubckt_4256_a2_x2 0 3793 1 3905 521 a2_x2
xsubckt_4203_o4_x2 0 3809 1 3818 7744 7745 7746 o4_x2
xsubckt_3570_nand4_x0 1 0 4405 5604 532 7689 63 nand4_x0
xsubckt_666_oa22_x2 0 7129 1 307 230 309 oa22_x2
xsubckt_1235_a2_x2 0 6596 1 7143 1856 a2_x2
xsubckt_1479_nand2_x0 1 0 6362 188 217 nand2_x0
xsubckt_1509_a2_x2 0 6332 1 6334 6359 a2_x2
xsubckt_1870_mx2_x2 0 5985 1 574 5986 6210 mx2_x2
xsubckt_1996_nand3_x0 1 0 5870 5872 5874 6403 nand3_x0
xsubckt_2081_nand3_x0 1 0 410 5795 7043 7053 nand3_x0
xsubckt_2438_a2_x2 0 5517 1 5518 7218 a2_x2
xsubckt_9675_sff1_x4 1 1872 0 8801 782 sff1_x4
xsubckt_9152_sff1_x4 1 1872 0 9306 601 sff1_x4
xsubckt_8701_sff1_x4 1 1872 0 9692 1126 sff1_x4
xsubckt_6996_ao22_x2 0 8303 1 7620 8307 8304 ao22_x2
xsubckt_6583_a2_x2 0 2063 1 7461 710 a2_x2
xsubckt_6368_mx2_x2 0 2273 1 710 1473 1313 mx2_x2
xsubckt_6303_nand2_x0 1 0 2337 2338 2339 nand2_x0
xsubckt_5966_mx3_x2 1 0 2666 712 710 2667 844 1356 mx3_x2
xsubckt_5831_mx2_x2 0 2795 1 710 776 1640 mx2_x2
xsubckt_5499_a2_x2 0 3044 1 3047 1863 a2_x2
xsubckt_5421_nand2_x0 1 0 3104 3109 3112 nand2_x0
xsubckt_4923_oa22_x2 0 9573 1 7168 3544 3545 oa22_x2
xsubckt_4894_nor3_x0 1 0 9581 3564 3565 7702 nor3_x0
xsubckt_3836_a2_x2 0 4144 1 4145 7217 a2_x2
xsubckt_3001_o2_x2 0 4964 1 4965 4967 o2_x2
xsubckt_2673_a2_x2 0 5286 1 5296 5300 a2_x2
xsubckt_2633_a2_x2 0 5325 1 5346 703 a2_x2
xsubckt_1111_ao22_x2 0 6713 1 6714 6718 7038 ao22_x2
xsubckt_847_xr2_x1 6966 0 1 676 51 xr2_x1
xsubckt_1490_a2_x2 0 6351 1 192 222 a2_x2
xsubckt_8775_sff1_x4 1 1872 0 9618 1796 sff1_x4
xsubckt_7281_ao22_x2 0 8110 1 645 7680 598 ao22_x2
xsubckt_6897_a2_x2 0 9386 1 8400 8446 a2_x2
xsubckt_6022_o2_x2 0 2611 1 2612 7134 o2_x2
xsubckt_5293_nor2_x0 1 0 3223 3224 3225 nor2_x0
xsubckt_5053_mx2_x2 0 3444 1 3540 7087 7680 mx2_x2
xsubckt_4889_nand4_x0 1 0 3567 3573 3574 1757 1756 nand4_x0
xsubckt_4306_mx3_x2 1 0 9946 3789 3896 740 3853 3855 mx3_x2
xsubckt_4304_mx3_x2 1 0 9948 3789 3897 742 3859 3860 mx3_x2
xsubckt_4302_mx3_x2 1 0 9950 3789 3897 714 3867 3868 mx3_x2
xsubckt_3863_o4_x2 0 4117 1 4118 4125 5594 5609 o4_x2
xsubckt_3856_a2_x2 0 4124 1 7153 7261 a2_x2
xsubckt_3136_nand2_x0 1 0 4832 224 696 nand2_x0
xsubckt_3061_o2_x2 0 4905 1 4906 703 o2_x2
xsubckt_1223_o2_x2 0 6607 1 6608 6609 o2_x2
xsubckt_1344_xr2_x1 6493 0 1 681 56 xr2_x1
xsubckt_1462_nand2_x0 1 0 6379 185 214 nand2_x0
xsubckt_9583_sff1_x4 1 1872 0 8890 933 sff1_x4
xsubckt_9148_sff1_x4 1 1872 0 9310 594 sff1_x4
xsubckt_9060_sff1_x4 1 1872 0 9366 1318 sff1_x4
xsubckt_7078_oa22_x2 0 8223 1 1551 710 712 oa22_x2
xsubckt_5282_oa22_x2 0 3233 1 7087 3234 3236 oa22_x2
xsubckt_5151_nand2_x0 1 0 3354 3517 7656 nand2_x0
xsubckt_4308_mx3_x2 1 0 9944 3789 3896 738 3847 3849 mx3_x2
xsubckt_4131_mx2_x2 0 3863 1 518 77 1873 mx2_x2
xsubckt_3338_ao22_x2 0 10068 1 4634 4671 4680 ao22_x2
xsubckt_1088_o2_x2 0 6735 1 6736 6737 o2_x2
xsubckt_1290_nxr2_x1 6544 1 0 6545 6551 nxr2_x1
xsubckt_9505_sff1_x4 1 1872 0 8961 942 sff1_x4
xsubckt_8683_sff1_x4 1 1872 0 9710 1431 sff1_x4
xsubckt_7342_nand3_x0 1 0 8065 8066 8076 8140 nand3_x0
xsubckt_5204_oa22_x2 0 3305 1 7680 3505 7167 oa22_x2
xsubckt_2873_ao22_x2 0 5090 1 777 7217 707 ao22_x2
xsubckt_1014_nand2_x0 1 0 6806 588 1804 nand2_x0
xsubckt_688_nand2_x0 1 0 7112 7194 7782 nand2_x0
xsubckt_92_inv_x0 1 0 96 7699 inv_x0
xsubckt_90_inv_x0 1 0 345 7701 inv_x0
xsubckt_1339_oa22_x2 0 151 1 1740 6508 6498 oa22_x2
xsubckt_1557_o2_x2 0 6284 1 434 218 o2_x2
xsubckt_2074_nand2_x0 1 0 5799 230 7687 nand2_x0
xsubckt_9579_sff1_x4 1 1872 0 8894 907 sff1_x4
xsubckt_9491_sff1_x4 1 1872 0 8975 1177 sff1_x4
xsubckt_9056_sff1_x4 1 1872 0 9370 1292 sff1_x4
xsubckt_8679_sff1_x4 1 1872 0 9714 1435 sff1_x4
xsubckt_8605_sff1_x4 1 1872 0 9788 1478 sff1_x4
xsubckt_8183_mx3_x2 1 0 8646 7802 3896 1647 3797 3798 mx3_x2
xsubckt_8181_mx3_x2 1 0 8648 7802 3896 1650 3802 3804 mx3_x2
xsubckt_8050_mx2_x2 0 8805 1 7807 3894 808 mx2_x2
xsubckt_6885_o2_x2 0 8411 1 1365 710 o2_x2
xsubckt_5936_o2_x2 0 2695 1 2696 7134 o2_x2
xsubckt_4093_mx2_x2 0 3893 1 518 107 1903 mx2_x2
xsubckt_3602_mx2_x2 0 4374 1 7217 7439 7441 mx2_x2
xsubckt_3600_mx2_x2 0 4376 1 705 1017 825 mx2_x2
xsubckt_98_inv_x0 1 0 577 7693 inv_x0
xsubckt_96_inv_x0 1 0 1738 7695 inv_x0
xsubckt_94_inv_x0 1 0 2 7697 inv_x0
xsubckt_9413_sff1_x4 1 1872 0 9053 1382 sff1_x4
xsubckt_8591_sff1_x4 1 1872 0 9802 1011 sff1_x4
xsubckt_8513_sff1_x4 1 1872 0 9880 994 sff1_x4
xsubckt_8056_mx2_x2 0 8799 1 7807 3874 780 mx2_x2
xsubckt_8054_mx2_x2 0 8801 1 7807 3882 782 mx2_x2
xsubckt_8052_mx2_x2 0 8803 1 7807 3890 796 mx2_x2
xsubckt_6966_oa22_x2 0 8332 1 7631 8333 711 oa22_x2
xsubckt_5841_nand2_x0 1 0 2785 7082 7135 nand2_x0
xsubckt_4097_mx2_x2 0 3890 1 3896 3891 7723 mx2_x2
xsubckt_4095_mx2_x2 0 10053 1 3898 3892 1607 mx2_x2
xsubckt_3874_nxr2_x1 4107 1 0 4108 4114 nxr2_x1
xsubckt_3736_nand2_x0 1 0 4242 4243 4244 nand2_x0
xsubckt_3560_mx2_x2 0 4415 1 705 1466 1306 mx2_x2
xsubckt_3217_mx2_x2 0 4752 1 706 1185 1121 mx2_x2
xsubckt_2504_oa22_x2 0 5452 1 704 5453 703 oa22_x2
xsubckt_9844_sff1_x4 1 1872 0 8632 1251 sff1_x4
xsubckt_9487_sff1_x4 1 1872 0 8979 1182 sff1_x4
xsubckt_9409_sff1_x4 1 1872 0 9057 1356 sff1_x4
xsubckt_8587_sff1_x4 1 1872 0 9806 1015 sff1_x4
xsubckt_7914_mx2_x2 0 8933 1 7815 3894 1224 mx2_x2
xsubckt_7093_ao22_x2 0 8208 1 712 8209 7613 ao22_x2
xsubckt_5186_oa22_x2 0 3322 1 7680 3508 7167 oa22_x2
xsubckt_5108_oa22_x2 0 3393 1 7087 3394 3396 oa22_x2
xsubckt_3953_mx2_x2 0 4029 1 705 1011 819 mx2_x2
xsubckt_3219_mx2_x2 0 4750 1 706 1057 961 mx2_x2
xsubckt_3173_mx2_x2 0 4795 1 705 1506 1346 mx2_x2
xsubckt_3154_ao22_x2 0 4814 1 4821 7215 704 ao22_x2
xsubckt_2750_nand4_x0 1 0 5210 5604 532 7689 49 nand4_x0
xsubckt_729_a2_x2 0 7074 1 7082 7142 a2_x2
xsubckt_411_inv_x0 1 0 1232 7380 inv_x0
xsubckt_413_inv_x0 1 0 944 7378 inv_x0
xsubckt_1882_nand2_x0 1 0 5974 6116 6326 nand2_x0
xsubckt_9395_sff1_x4 1 1872 0 9066 355 sff1_x4
xsubckt_9321_sff1_x4 1 1872 0 9140 1341 sff1_x4
xsubckt_8944_sff1_x4 1 1872 0 9449 1812 sff1_x4
xsubckt_8509_sff1_x4 1 1872 0 9884 998 sff1_x4
xsubckt_8421_sff1_x4 1 1872 0 9972 894 sff1_x4
xsubckt_7918_mx2_x2 0 8929 1 7815 3882 1198 mx2_x2
xsubckt_7916_mx2_x2 0 8931 1 7815 3890 1212 mx2_x2
xsubckt_7450_ao22_x2 0 8003 1 7131 7195 531 ao22_x2
xsubckt_6453_nand2_x0 1 0 2190 2191 7613 nand2_x0
xsubckt_4179_nor3_x0 1 0 3827 3833 7739 7740 nor3_x0
xsubckt_3466_nand2_x0 1 0 4508 4509 4511 nand2_x0
xsubckt_1155_oa22_x2 0 6672 1 399 7044 6880 oa22_x2
xsubckt_789_a2_x2 0 7021 1 7143 1870 a2_x2
xsubckt_371_inv_x0 1 0 791 7420 inv_x0
xsubckt_415_inv_x0 1 0 1359 7376 inv_x0
xsubckt_417_inv_x0 1 0 911 7374 inv_x0
xsubckt_419_inv_x0 1 0 847 7372 inv_x0
xsubckt_1354_ao22_x2 0 6483 1 6484 6488 7038 ao22_x2
xsubckt_1614_nand2_x0 1 0 6227 6233 6242 nand2_x0
xsubckt_9752_sff1_x4 1 1872 0 8724 1727 sff1_x4
xsubckt_9317_sff1_x4 1 1872 0 9144 1345 sff1_x4
xsubckt_8495_sff1_x4 1 1872 0 9898 1523 sff1_x4
xsubckt_7485_mx2_x2 0 9225 1 7986 313 418 mx2_x2
xsubckt_7483_mx2_x2 0 9227 1 7986 315 420 mx2_x2
xsubckt_7481_mx2_x2 0 9229 1 7986 329 434 mx2_x2
xsubckt_7092_mx2_x2 0 8209 1 710 1007 815 mx2_x2
xsubckt_7090_mx2_x2 0 8211 1 710 911 783 mx2_x2
xsubckt_6603_mx2_x2 0 2043 1 710 1019 827 mx2_x2
xsubckt_6601_mx2_x2 0 2045 1 710 1435 1275 mx2_x2
xsubckt_6273_nand2_x0 1 0 2366 2367 7628 nand2_x0
xsubckt_6212_mx2_x2 0 2426 1 712 1092 1060 mx2_x2
xsubckt_6210_mx2_x2 0 2428 1 712 1156 1124 mx2_x2
xsubckt_5657_nand3_x0 1 0 2929 2935 1816 1817 nand3_x0
xsubckt_4642_a4_x2 0 3760 1 644 1807 1806 1742 a4_x2
xsubckt_3942_ao22_x2 0 4040 1 4041 4043 703 ao22_x2
xsubckt_3220_oa22_x2 0 4749 1 4750 705 7219 oa22_x2
xsubckt_3108_nand2_x0 1 0 4859 4860 4862 nand2_x0
xsubckt_2486_oa22_x2 0 5470 1 1212 7219 705 oa22_x2
xsubckt_373_inv_x0 1 0 1399 7418 inv_x0
xsubckt_375_inv_x0 1 0 1239 7416 inv_x0
xsubckt_8852_sff1_x4 1 1872 0 9541 128 sff1_x4
xsubckt_8417_sff1_x4 1 1872 0 9976 898 sff1_x4
xsubckt_7672_nand3_x0 1 0 7855 7857 7679 644 nand3_x0
xsubckt_7489_mx2_x2 0 9221 1 7985 444 339 mx2_x2
xsubckt_7487_mx2_x2 0 9223 1 7985 416 311 mx2_x2
xsubckt_7446_ao22_x2 0 8006 1 7658 372 538 ao22_x2
xsubckt_7282_a3_x2 1 8109 0 533 7679 644 a3_x2
xsubckt_6952_mx2_x2 0 8346 1 710 8347 8348 mx2_x2
xsubckt_6950_mx2_x2 0 8348 1 712 1075 1043 mx2_x2
xsubckt_6605_mx2_x2 0 2041 1 708 2042 2044 mx2_x2
xsubckt_6561_mx2_x2 0 2084 1 710 1149 989 mx2_x2
xsubckt_6218_mx2_x2 0 2420 1 710 1700 1572 mx2_x2
xsubckt_6214_mx2_x2 0 2424 1 710 2425 2426 mx2_x2
xsubckt_5289_ao22_x2 0 3227 1 600 3228 644 ao22_x2
xsubckt_4730_a3_x2 1 9619 0 3690 3691 40 a3_x2
xsubckt_4662_a4_x2 0 3745 1 3749 3754 3763 1751 a4_x2
xsubckt_4114_a2_x2 0 3877 1 3881 49 a2_x2
xsubckt_3400_a2_x2 0 4572 1 4574 4577 a2_x2
xsubckt_2843_oa22_x2 0 5119 1 5120 5123 703 oa22_x2
xsubckt_377_inv_x0 1 0 1175 7414 inv_x0
xsubckt_379_inv_x0 1 0 1047 7412 inv_x0
xsubckt_1698_nand3_x0 1 0 6143 6145 6197 6426 nand3_x0
xsubckt_2257_mx2_x2 0 5695 1 710 1489 1329 mx2_x2
xsubckt_2259_mx2_x2 0 5693 1 7628 5694 5695 mx2_x2
xsubckt_9748_sff1_x4 1 1872 0 8728 1731 sff1_x4
xsubckt_9660_sff1_x4 1 1872 0 8816 826 sff1_x4
xsubckt_9225_sff1_x4 1 1872 0 9236 537 sff1_x4
xsubckt_7604_a2_x2 0 9178 1 7912 7916 a2_x2
xsubckt_7175_a2_x2 0 8162 1 596 1737 a2_x2
xsubckt_6956_mx2_x2 0 8342 1 710 1683 1555 mx2_x2
xsubckt_6698_mx3_x2 1 0 1950 7628 7613 1951 1957 1959 mx3_x2
xsubckt_6696_mx3_x2 1 0 1952 712 710 1953 793 921 mx3_x2
xsubckt_6546_ao22_x2 0 2099 1 2100 2102 2103 ao22_x2
xsubckt_5532_a2_x2 0 3020 1 3023 1853 a2_x2
xsubckt_5317_a2_x2 0 3201 1 3477 665 a2_x2
xsubckt_5083_a2_x2 0 3416 1 3417 644 a2_x2
xsubckt_5063_a2_x2 0 3435 1 3537 646 a2_x2
xsubckt_2999_mx2_x2 0 4966 1 707 837 805 mx2_x2
xsubckt_2997_mx2_x2 0 4968 1 707 1029 933 mx2_x2
xsubckt_2858_xr2_x1 5105 0 1 199 671 xr2_x1
xsubckt_952_o2_x2 0 141 1 6866 6883 o2_x2
xsubckt_646_nand4_x0 1 0 7149 7151 7153 7156 7157 nand4_x0
xsubckt_1861_nand3_x0 1 0 5993 5994 5995 6111 nand3_x0
xsubckt_1890_nxr2_x1 5967 1 0 5968 6348 nxr2_x1
xsubckt_2136_nand2_x0 1 0 5759 7044 181 nand2_x0
xsubckt_2316_oa22_x2 0 5637 1 5638 710 712 oa22_x2
xsubckt_9299_sff1_x4 1 1872 0 9162 679 sff1_x4
xsubckt_8848_sff1_x4 1 1872 0 9545 55 sff1_x4
xsubckt_8760_sff1_x4 1 1872 0 9633 1773 sff1_x4
xsubckt_8325_sff1_x4 1 1872 0 10060 212 sff1_x4
xsubckt_7845_nand2_x0 1 0 7819 3769 3900 nand2_x0
xsubckt_6977_ao22_x2 0 8321 1 8322 8326 7613 ao22_x2
xsubckt_6715_a2_x2 0 8578 1 7424 710 a2_x2
xsubckt_6178_mx2_x2 0 2459 1 710 1701 1573 mx2_x2
xsubckt_5798_a3_x2 1 2827 0 2828 2829 2854 a3_x2
xsubckt_5778_a3_x2 1 2845 0 2846 7195 40 a3_x2
xsubckt_5726_nand4_x0 1 0 2865 5604 532 7689 52 nand4_x0
xsubckt_2515_ao22_x2 0 5441 1 7594 7217 707 ao22_x2
xsubckt_2469_xr2_x1 5486 0 1 701 229 xr2_x1
xsubckt_1053_o3_x2 0 6769 1 404 308 307 o3_x2
xsubckt_1467_a2_x2 0 6374 1 186 215 a2_x2
xsubckt_2363_o4_x2 0 5591 1 653 651 650 666 o4_x2
xsubckt_9656_sff1_x4 1 1872 0 8820 831 sff1_x4
xsubckt_9133_sff1_x4 1 1872 0 9325 1151 sff1_x4
xsubckt_8756_sff1_x4 1 1872 0 9637 1807 sff1_x4
xsubckt_8399_sff1_x4 1 1872 0 10091 708 sff1_x4
xsubckt_7665_nand2_x0 1 0 7861 660 600 nand2_x0
xsubckt_6811_ao22_x2 0 8484 1 7409 7625 712 ao22_x2
xsubckt_5813_nand2_x0 1 0 2813 2814 709 nand2_x0
xsubckt_5119_ao22_x2 0 3383 1 3385 3387 600 ao22_x2
xsubckt_9129_sff1_x4 1 1872 0 9329 1155 sff1_x4
xsubckt_6783_nand2_x0 1 0 8511 8512 7628 nand2_x0
xsubckt_6686_oa22_x2 0 1962 1 1963 1978 7620 oa22_x2
xsubckt_6608_oa22_x2 0 2038 1 2039 2052 2728 oa22_x2
xsubckt_5996_mx2_x2 0 2637 1 710 907 779 mx2_x2
xsubckt_4509_mx3_x2 1 0 9759 3773 3897 1067 3871 3872 mx3_x2
xsubckt_4463_mx3_x2 1 0 9801 3777 3896 1010 3802 3804 mx3_x2
xsubckt_4461_mx3_x2 1 0 9803 3777 3896 1012 3808 3810 mx3_x2
xsubckt_4330_mx2_x2 0 9925 1 3785 3892 1543 mx2_x2
xsubckt_3528_nand2_x0 1 0 4447 4448 707 nand2_x0
xsubckt_1271_nxr2_x1 6562 1 0 6564 6565 nxr2_x1
xsubckt_1435_o2_x2 0 6406 1 183 212 o2_x2
xsubckt_9564_sff1_x4 1 1872 0 8909 1207 sff1_x4
xsubckt_9041_sff1_x4 1 1872 0 9385 181 sff1_x4
xsubckt_8664_sff1_x4 1 1872 0 9729 1421 sff1_x4
xsubckt_8033_mx3_x2 1 0 8820 7810 3896 831 3838 3840 mx3_x2
xsubckt_8031_mx3_x2 1 0 8822 7810 3896 833 3844 3846 mx3_x2
xsubckt_7416_oa22_x2 0 8020 1 7132 7194 667 oa22_x2
xsubckt_7307_nand2_x0 1 0 8092 8095 8105 nand2_x0
xsubckt_6099_o2_x2 0 2536 1 713 710 o2_x2
xsubckt_5998_mx2_x2 0 2635 1 710 1003 811 mx2_x2
xsubckt_5719_nand3_x0 1 0 2872 2890 2904 706 nand3_x0
xsubckt_4837_nand3_x0 1 0 3607 3613 1770 1769 nand3_x0
xsubckt_4465_mx3_x2 1 0 9799 3777 3896 1007 3797 3798 mx3_x2
xsubckt_4334_mx2_x2 0 9921 1 3785 3878 1517 mx2_x2
xsubckt_4332_mx2_x2 0 9923 1 3785 3886 1521 mx2_x2
xsubckt_3527_o2_x2 0 4448 1 705 1658 o2_x2
xsubckt_2646_nand2_x0 1 0 5312 5317 5319 nand2_x0
xsubckt_1074_ao22_x2 0 6749 1 6772 6755 6752 ao22_x2
xsubckt_1600_nor2_x0 1 0 6241 6242 6301 nor2_x0
xsubckt_1729_o2_x2 0 6112 1 591 592 o2_x2
xsubckt_9472_sff1_x4 1 1872 0 8994 1169 sff1_x4
xsubckt_9037_sff1_x4 1 1872 0 9389 185 sff1_x4
xsubckt_8039_mx3_x2 1 0 8814 7810 3896 824 3820 3822 mx3_x2
xsubckt_8037_mx3_x2 1 0 8816 7810 3896 826 3826 3828 mx3_x2
xsubckt_8035_mx3_x2 1 0 8818 7810 3896 829 3832 3834 mx3_x2
xsubckt_7808_nxr2_x1 7823 1 0 7107 7683 nxr2_x1
xsubckt_7127_nand2_x0 1 0 8175 8176 40 nand2_x0
xsubckt_6594_oa22_x2 0 2052 1 2053 2066 7620 oa22_x2
xsubckt_3782_o2_x2 0 4197 1 4198 7216 o2_x2
xsubckt_2853_o2_x2 0 5109 1 5110 5593 o2_x2
xsubckt_820_oa22_x2 0 6991 1 6992 6996 7037 oa22_x2
xsubckt_8572_sff1_x4 1 1872 0 9821 1001 sff1_x4
xsubckt_8083_nand4_x0 1 0 7805 3790 3901 3903 3906 nand4_x0
xsubckt_7324_oa22_x2 0 8081 1 7679 644 7692 oa22_x2
xsubckt_7113_mx3_x2 1 0 8188 7620 7613 8189 8194 8197 mx3_x2
xsubckt_7111_mx3_x2 1 0 8190 712 710 8191 1583 719 mx3_x2
xsubckt_5370_ao22_x2 0 3151 1 600 3152 644 ao22_x2
xsubckt_5128_nxr2_x1 3375 1 0 3376 3379 nxr2_x1
xsubckt_4298_mx2_x2 0 9954 1 3788 3882 718 mx2_x2
xsubckt_4296_mx2_x2 0 9956 1 3788 3890 732 mx2_x2
xsubckt_4294_mx2_x2 0 9958 1 3788 3894 744 mx2_x2
xsubckt_4035_ao22_x2 0 3949 1 7218 3951 3950 ao22_x2
xsubckt_3890_mx3_x2 1 0 4091 707 705 4092 1588 724 mx3_x2
xsubckt_3820_oa22_x2 0 4160 1 4216 4211 4214 oa22_x2
xsubckt_3416_mx2_x2 0 4557 1 705 1405 1245 mx2_x2
xsubckt_3414_mx2_x2 0 4559 1 705 1693 1565 mx2_x2
xsubckt_3412_mx2_x2 0 4561 1 705 1149 989 mx2_x2
xsubckt_3168_nand2_x0 1 0 4800 4801 4802 nand2_x0
xsubckt_2563_oa22_x2 0 5394 1 704 5395 5397 oa22_x2
xsubckt_622_nand3_x0 1 0 7169 7170 7173 7176 nand3_x0
xsubckt_1584_nand2_x0 1 0 6257 7249 201 nand2_x0
xsubckt_2040_oa22_x2 0 1915 1 5835 5834 5830 oa22_x2
xsubckt_2327_ao22_x2 0 5626 1 7625 846 5627 ao22_x2
xsubckt_9468_sff1_x4 1 1872 0 8998 1391 sff1_x4
xsubckt_9380_sff1_x4 1 1872 0 9081 371 sff1_x4
xsubckt_8259_mx2_x2 0 9259 1 5752 9076 666 mx2_x2
xsubckt_7855_mx3_x2 1 0 8988 7820 3897 1161 3863 3864 mx3_x2
xsubckt_7853_mx3_x2 1 0 8990 7820 3897 1163 3871 3872 mx3_x2
xsubckt_7523_ao22_x2 0 9197 1 7974 7975 7976 ao22_x2
xsubckt_5889_ao22_x2 0 2738 1 7597 7079 2739 ao22_x2
xsubckt_5366_ao22_x2 0 3155 1 3166 3162 3157 ao22_x2
xsubckt_5167_oa22_x2 0 3339 1 3356 3354 3355 oa22_x2
xsubckt_3894_mx3_x2 1 0 4087 707 705 4088 1044 1172 mx3_x2
xsubckt_3418_mx2_x2 0 4555 1 707 4556 4557 mx2_x2
xsubckt_3371_oa22_x2 0 4601 1 1214 7217 4602 oa22_x2
xsubckt_3029_mx2_x2 0 4937 1 705 1700 1572 mx2_x2
xsubckt_2621_mx3_x2 1 0 5337 707 705 5338 7574 7576 mx3_x2
xsubckt_709_nor3_x0 1 0 7092 7094 7097 7103 nor3_x0
xsubckt_221_inv_x0 1 0 1325 7570 inv_x0
xsubckt_1833_nand3_x0 1 0 6018 6019 6020 6021 nand3_x0
xsubckt_2108_nand2_x0 1 0 5773 195 307 nand2_x0
xsubckt_9825_sff1_x4 1 1872 0 8651 1653 sff1_x4
xsubckt_9302_sff1_x4 1 1872 0 9159 1352 sff1_x4
xsubckt_8568_sff1_x4 1 1872 0 9825 1005 sff1_x4
xsubckt_8480_sff1_x4 1 1872 0 9913 1539 sff1_x4
xsubckt_7859_mx3_x2 1 0 8984 7820 3896 1187 3850 3852 mx3_x2
xsubckt_7857_mx3_x2 1 0 8986 7820 3897 1189 3856 3857 mx3_x2
xsubckt_7519_ao22_x2 0 9198 1 7977 7978 7979 ao22_x2
xsubckt_4500_a4_x2 0 3773 1 3783 3901 3903 3906 a4_x2
xsubckt_3376_mx2_x2 0 4596 1 705 1438 1278 mx2_x2
xsubckt_2972_mx3_x2 1 0 4993 707 705 4994 7522 7524 mx3_x2
xsubckt_1136_oa22_x2 0 6690 1 6709 6704 6691 oa22_x2
xsubckt_687_a2_x2 0 7113 1 7179 7782 a2_x2
xsubckt_654_o4_x2 0 7141 1 587 588 589 590 o4_x2
xsubckt_570_inv_x0 1 0 528 7221 inv_x0
xsubckt_223_inv_x0 1 0 1516 7568 inv_x0
xsubckt_225_inv_x0 1 0 907 7566 inv_x0
xsubckt_227_inv_x0 1 0 779 7564 inv_x0
xsubckt_1743_nand3_x0 1 0 6099 6100 6101 6102 nand3_x0
xsubckt_2238_mx3_x2 1 0 5713 712 710 5714 1532 1660 mx3_x2
xsubckt_9376_sff1_x4 1 1872 0 9085 375 sff1_x4
xsubckt_8999_sff1_x4 1 1872 0 9426 501 sff1_x4
xsubckt_8925_sff1_x4 1 1872 0 9468 1833 sff1_x4
xsubckt_8402_sff1_x4 1 1872 0 296 41 sff1_x4
xsubckt_7239_nor2_x0 1 0 8141 8142 8143 nor2_x0
xsubckt_5528_a4_x2 0 3023 1 3031 1854 1855 1856 a4_x2
xsubckt_5518_nand4_x0 1 0 3030 3039 1857 1858 1860 nand4_x0
xsubckt_4726_nand4_x0 1 0 3692 3696 3707 3711 1798 nand4_x0
xsubckt_3582_xr2_x1 4394 0 1 215 687 xr2_x1
xsubckt_576_inv_x0 1 0 703 7215 inv_x0
xsubckt_574_inv_x0 1 0 705 7217 inv_x0
xsubckt_572_inv_x0 1 0 707 7219 inv_x0
xsubckt_183_inv_x0 1 0 935 7608 inv_x0
xsubckt_181_inv_x0 1 0 1383 7610 inv_x0
xsubckt_229_inv_x0 1 0 1643 7562 inv_x0
xsubckt_1335_ao22_x2 0 6501 1 6502 6506 7038 ao22_x2
xsubckt_9733_sff1_x4 1 1872 0 8743 752 sff1_x4
xsubckt_9210_sff1_x4 1 1872 0 9248 649 sff1_x4
xsubckt_8833_sff1_x4 1 1872 0 9560 71 sff1_x4
xsubckt_8476_sff1_x4 1 1872 0 9917 1513 sff1_x4
xsubckt_7688_mx2_x2 0 9163 1 8139 7843 676 mx2_x2
xsubckt_7547_nand2_x0 1 0 7956 7957 8140 nand2_x0
xsubckt_7386_a4_x2 0 8032 1 8033 8034 350 7639 a4_x2
xsubckt_6760_mx2_x2 0 8534 1 710 8535 8536 mx2_x2
xsubckt_6417_mx2_x2 0 2225 1 710 1408 1248 mx2_x2
xsubckt_6415_mx2_x2 0 2227 1 710 1728 896 mx2_x2
xsubckt_6413_mx2_x2 0 2229 1 710 1504 1344 mx2_x2
xsubckt_4854_a4_x2 0 3595 1 1768 1767 1766 1765 a4_x2
xsubckt_4052_a2_x2 0 3932 1 705 7379 a2_x2
xsubckt_3979_xr2_x1 4004 0 1 208 680 xr2_x1
xsubckt_3768_nand2_x0 1 0 4211 212 684 nand2_x0
xsubckt_2859_nxr2_x1 5104 1 0 199 671 nxr2_x1
xsubckt_2704_xr2_x1 5256 0 1 202 674 xr2_x1
xsubckt_578_inv_x0 1 0 522 7213 inv_x0
xsubckt_189_inv_x0 1 0 1671 7602 inv_x0
xsubckt_187_inv_x0 1 0 807 7604 inv_x0
xsubckt_185_inv_x0 1 0 871 7606 inv_x0
xsubckt_1916_nand2_x0 1 0 5943 6112 6341 nand2_x0
xsubckt_2019_a2_x2 0 5849 1 5850 574 a2_x2
xsubckt_9729_sff1_x4 1 1872 0 8747 757 sff1_x4
xsubckt_9284_sff1_x4 1 1872 0 9177 692 sff1_x4
xsubckt_9206_sff1_x4 1 1872 0 9252 653 sff1_x4
xsubckt_8310_sff1_x4 1 1872 0 10075 228 sff1_x4
xsubckt_7327_a2_x2 0 8078 1 8079 8080 a2_x2
xsubckt_7279_a3_x2 1 8111 0 8112 8144 8154 a3_x2
xsubckt_7073_a2_x2 0 9382 1 8228 8275 a2_x2
xsubckt_6762_mx2_x2 0 8532 1 7625 7417 7419 mx2_x2
xsubckt_6419_mx2_x2 0 2223 1 712 2224 2225 mx2_x2
xsubckt_6373_mx2_x2 0 2268 1 7631 2269 2270 mx2_x2
xsubckt_6371_mx2_x2 0 2270 1 710 1729 897 mx2_x2
xsubckt_6247_nor2_x0 1 0 2391 2392 7134 nor2_x0
xsubckt_6028_mx2_x2 0 2606 1 710 2607 2608 mx2_x2
xsubckt_6026_mx2_x2 0 2608 1 712 970 938 mx2_x2
xsubckt_5783_nand2_x0 1 0 2840 2841 7074 nand2_x0
xsubckt_5656_a3_x2 1 2930 0 2935 1816 1817 a3_x2
xsubckt_5509_a2_x2 0 9493 1 3037 3038 a2_x2
xsubckt_5301_nxr2_x1 3216 1 0 3481 7672 nxr2_x1
xsubckt_5215_a2_x2 0 3295 1 3501 653 a2_x2
xsubckt_4731_ao22_x2 0 3689 1 3692 7707 7708 ao22_x2
xsubckt_4707_a3_x2 1 3708 0 644 1751 1742 a3_x2
xsubckt_3931_nand2_x0 1 0 4051 705 1043 nand2_x0
xsubckt_3588_nand2_x0 1 0 4388 4389 4391 nand2_x0
xsubckt_3143_a2_x2 0 4825 1 4826 706 a2_x2
xsubckt_2618_nand2_x0 1 0 5340 5341 5342 nand2_x0
xsubckt_1091_a2_x2 0 6733 1 695 70 a2_x2
xsubckt_909_o2_x2 0 6907 1 673 48 o2_x2
xsubckt_1325_a2_x2 0 6511 1 682 57 a2_x2
xsubckt_1736_nand2_x0 1 0 6105 6106 6109 nand2_x0
xsubckt_1871_nxr2_x1 5984 1 0 5985 6205 nxr2_x1
xsubckt_2079_a2_x2 0 5796 1 230 229 a2_x2
xsubckt_9641_sff1_x4 1 1872 0 8835 828 sff1_x4
xsubckt_8829_sff1_x4 1 1872 0 9564 75 sff1_x4
xsubckt_8741_sff1_x4 1 1872 0 9652 1278 sff1_x4
xsubckt_8384_sff1_x4 1 1872 0 10001 1562 sff1_x4
xsubckt_8306_sff1_x4 1 1872 0 10079 202 sff1_x4
xsubckt_7571_oa22_x2 0 7937 1 644 7679 683 oa22_x2
xsubckt_7367_nand2_x0 1 0 9277 8048 8049 nand2_x0
xsubckt_6673_a2_x2 0 1975 1 7435 710 a2_x2
xsubckt_6375_mx2_x2 0 2266 1 710 1217 1089 mx2_x2
xsubckt_5973_mx3_x2 1 0 2659 7628 7613 2660 2666 2668 mx3_x2
xsubckt_5971_mx3_x2 1 0 2661 712 710 2662 780 908 mx3_x2
xsubckt_5724_a2_x2 0 2867 1 2868 7153 a2_x2
xsubckt_5275_a2_x2 0 3240 1 3486 665 a2_x2
xsubckt_4963_oa22_x2 0 9563 1 7168 3513 3515 oa22_x2
xsubckt_4835_a2_x2 0 9595 1 3609 3611 a2_x2
xsubckt_4815_a2_x2 0 9600 1 3624 3626 a2_x2
xsubckt_4787_a3_x2 1 3645 0 3646 3657 1786 a3_x2
xsubckt_4767_a3_x2 1 9611 0 3661 3663 40 a3_x2
xsubckt_3130_nand3_x0 1 0 4837 4838 5595 5608 nand3_x0
xsubckt_2703_a2_x2 0 5257 1 202 674 a2_x2
xsubckt_2695_a3_x2 1 5264 0 5265 5266 7104 a3_x2
xsubckt_1002_xr2_x1 6818 0 1 699 74 xr2_x1
xsubckt_628_oa22_x2 0 7163 1 7192 7164 7168 oa22_x2
xsubckt_1385_a2_x2 0 6454 1 7143 1847 a2_x2
xsubckt_1646_nand2_x0 1 0 6195 7223 221 nand2_x0
xsubckt_2099_a2_x2 0 5780 1 5781 5782 a2_x2
xsubckt_9637_sff1_x4 1 1872 0 10097 308 sff1_x4
xsubckt_9192_sff1_x4 1 1872 0 9266 661 sff1_x4
xsubckt_9114_sff1_x4 1 1872 0 1912 1880 sff1_x4
xsubckt_7567_oa22_x2 0 7940 1 644 7679 682 oa22_x2
xsubckt_6435_ao22_x2 0 2208 1 709 2209 708 ao22_x2
xsubckt_6395_nand2_x0 1 0 2247 2248 2249 nand2_x0
xsubckt_6217_nand2_x0 1 0 2421 2422 2423 nand2_x0
xsubckt_5846_mx2_x2 0 2781 1 710 1031 839 mx2_x2
xsubckt_4856_nor3_x0 1 0 3593 3594 3605 3631 nor3_x0
xsubckt_4313_mx3_x2 1 0 9939 3789 3896 733 3832 3834 mx3_x2
xsubckt_4311_mx3_x2 1 0 9941 3789 3896 735 3838 3840 mx3_x2
xsubckt_3926_a2_x2 0 4056 1 4057 7216 a2_x2
xsubckt_3126_nand4_x0 1 0 4841 5604 532 7689 72 nand4_x0
xsubckt_2601_nxr2_x1 5357 1 0 5358 5359 nxr2_x1
xsubckt_2588_a2_x2 0 5369 1 207 679 a2_x2
xsubckt_1889_mx2_x2 0 5968 1 574 5969 6199 mx2_x2
xsubckt_2007_o2_x2 0 5860 1 5862 7788 o2_x2
xsubckt_9188_sff1_x4 1 1872 0 9270 587 sff1_x4
xsubckt_8737_sff1_x4 1 1872 0 9656 1282 sff1_x4
xsubckt_7401_oa22_x2 0 9270 1 8025 8022 8021 oa22_x2
xsubckt_7243_ao22_x2 0 8138 1 645 7680 40 ao22_x2
xsubckt_7097_nand2_x0 1 0 8204 8205 8206 nand2_x0
xsubckt_7061_o2_x2 0 8239 1 1360 710 o2_x2
xsubckt_4959_oa22_x2 0 9564 1 7168 3516 3518 oa22_x2
xsubckt_4319_mx3_x2 1 0 9933 3789 3896 726 3814 3816 mx3_x2
xsubckt_4317_mx3_x2 1 0 9935 3789 3896 728 3820 3822 mx3_x2
xsubckt_4315_mx3_x2 1 0 9937 3789 3896 730 3826 3828 mx3_x2
xsubckt_4271_mx3_x2 1 0 9978 3792 3896 900 3853 3855 mx3_x2
xsubckt_4215_nor4_x0 1 0 3800 3809 7747 7748 7749 nor4_x0
xsubckt_1754_o3_x2 0 6090 1 6272 6285 7788 o3_x2
xsubckt_9545_sff1_x4 1 1872 0 8928 1197 sff1_x4
xsubckt_9022_sff1_x4 1 1872 0 9404 176 sff1_x4
xsubckt_8234_mx3_x2 1 0 8599 7798 3896 1634 3847 3849 mx3_x2
xsubckt_8232_mx3_x2 1 0 8601 7798 3896 1636 3853 3855 mx3_x2
xsubckt_8230_mx3_x2 1 0 8603 7798 3897 1638 3859 3860 mx3_x2
xsubckt_7600_ao22_x2 0 7915 1 607 594 366 ao22_x2
xsubckt_7550_o2_x2 0 7953 1 531 536 o2_x2
xsubckt_7260_nand2_x0 1 0 9304 8125 8126 nand2_x0
xsubckt_5244_oa22_x2 0 3268 1 3270 3271 7690 oa22_x2
xsubckt_5191_nxr2_x1 3317 1 0 3508 668 nxr2_x1
xsubckt_4926_mx2_x2 0 3540 1 5753 3891 128 mx2_x2
xsubckt_4277_mx3_x2 1 0 9972 3792 3896 894 3835 3837 mx3_x2
xsubckt_4275_mx3_x2 1 0 9974 3792 3896 896 3841 3843 mx3_x2
xsubckt_4273_mx3_x2 1 0 9976 3792 3896 898 3847 3849 mx3_x2
xsubckt_4142_mx2_x2 0 3855 1 518 104 1900 mx2_x2
xsubckt_4140_mx2_x2 0 3856 1 518 105 1901 mx2_x2
xsubckt_3735_ao22_x2 0 4243 1 791 7217 707 ao22_x2
xsubckt_3567_nand3_x0 1 0 4408 4409 4575 7104 nand3_x0
xsubckt_2636_oa22_x2 0 5322 1 5323 5324 5587 oa22_x2
xsubckt_1108_nand2_x0 1 0 6716 1829 589 nand2_x0
xsubckt_945_nand2_x0 1 0 6872 1836 589 nand2_x0
xsubckt_1252_nxr2_x1 6580 1 0 6581 6587 nxr2_x1
xsubckt_1291_oa22_x2 0 6543 1 391 7044 6880 oa22_x2
xsubckt_2078_nand2_x0 1 0 411 5798 7051 nand2_x0
xsubckt_9096_sff1_x4 1 1872 0 1932 1900 sff1_x4
xsubckt_8645_sff1_x4 1 1872 0 9748 1086 sff1_x4
xsubckt_8238_mx3_x2 1 0 8595 7798 3896 1630 3835 3837 mx3_x2
xsubckt_8236_mx3_x2 1 0 8597 7798 3896 1632 3841 3843 mx3_x2
xsubckt_7674_ao22_x2 0 7854 1 7953 8018 358 ao22_x2
xsubckt_6943_nor2_x0 1 0 8354 8355 7134 nor2_x0
xsubckt_6464_nand3_x0 1 0 2179 2180 2181 708 nand3_x0
xsubckt_5792_o2_x2 0 9415 1 2832 2851 o2_x2
xsubckt_5113_nxr2_x1 3389 1 0 3395 3526 nxr2_x1
xsubckt_4539_mx2_x2 0 9731 1 3770 3886 1425 mx2_x2
xsubckt_4537_mx2_x2 0 9733 1 3770 3892 1447 mx2_x2
xsubckt_4279_mx3_x2 1 0 9970 3792 3896 891 3829 3831 mx3_x2
xsubckt_4146_mx2_x2 0 3852 1 518 103 1899 mx2_x2
xsubckt_3009_oa22_x2 0 4956 1 4957 4960 4963 oa22_x2
xsubckt_3004_mx3_x2 1 0 4961 707 705 4962 1317 1477 mx3_x2
xsubckt_855_nand2_x0 1 0 6958 6959 7047 nand2_x0
xsubckt_801_oa22_x2 0 170 1 1737 7022 7010 oa22_x2
xsubckt_2331_nand2_x0 1 0 5622 5623 5628 nand2_x0
xsubckt_9453_sff1_x4 1 1872 0 9013 1408 sff1_x4
xsubckt_9018_sff1_x4 1 1872 0 9408 420 sff1_x4
xsubckt_8196_mx3_x2 1 0 8635 7800 3897 1254 3859 3860 mx3_x2
xsubckt_8194_mx3_x2 1 0 8637 7800 3897 1226 3867 3868 mx3_x2
xsubckt_5845_nand2_x0 1 0 9412 2782 2784 nand2_x0
xsubckt_5492_nand3_x0 1 0 3049 3055 1865 1866 nand3_x0
xsubckt_5439_ao22_x2 0 3087 1 600 3088 644 ao22_x2
xsubckt_5351_ao22_x2 0 3169 1 3474 3477 665 ao22_x2
xsubckt_3746_mx3_x2 1 0 4232 707 705 4233 1303 1463 mx3_x2
xsubckt_3033_nand2_x0 1 0 4933 4934 707 nand2_x0
xsubckt_9810_sff1_x4 1 1872 0 8666 1669 sff1_x4
xsubckt_9449_sff1_x4 1 1872 0 9017 1412 sff1_x4
xsubckt_8910_sff1_x4 1 1872 0 9483 1850 sff1_x4
xsubckt_8553_sff1_x4 1 1872 0 9840 1497 sff1_x4
xsubckt_8198_mx3_x2 1 0 8633 7800 3896 1252 3853 3855 mx3_x2
xsubckt_7582_ao22_x2 0 9183 1 7956 7929 7931 ao22_x2
xsubckt_6547_nand2_x0 1 0 2098 2099 711 nand2_x0
xsubckt_3228_mx2_x2 0 4741 1 703 4742 4747 mx2_x2
xsubckt_2824_mx3_x2 1 0 5138 707 705 5139 7543 7547 mx3_x2
xsubckt_1121_oa22_x2 0 6704 1 6732 6727 6707 oa22_x2
xsubckt_740_a2_x2 0 7064 1 530 40 a2_x2
xsubckt_420_inv_x0 1 0 815 7371 inv_x0
xsubckt_2095_oa22_x2 0 5783 1 7685 308 7240 oa22_x2
xsubckt_9884_sff1_x4 1 1872 0 8592 1626 sff1_x4
xsubckt_9806_sff1_x4 1 1872 0 8670 1643 sff1_x4
xsubckt_9361_sff1_x4 1 1872 0 9100 1044 sff1_x4
xsubckt_8984_sff1_x4 1 1872 0 9441 487 sff1_x4
xsubckt_8549_sff1_x4 1 1872 0 9844 1502 sff1_x4
xsubckt_7578_ao22_x2 0 9184 1 7956 7932 7934 ao22_x2
xsubckt_7339_nand2_x0 1 0 8068 8138 611 nand2_x0
xsubckt_7291_oa22_x2 0 9297 1 8130 8109 8104 oa22_x2
xsubckt_7143_mx2_x2 0 9373 1 8166 3886 1297 mx2_x2
xsubckt_7141_mx2_x2 0 9375 1 8166 3892 1319 mx2_x2
xsubckt_6847_nor2_x0 1 0 8448 8449 7134 nor2_x0
xsubckt_6479_oa22_x2 0 2165 1 2166 710 711 oa22_x2
xsubckt_6457_nand2_x0 1 0 2186 2187 712 nand2_x0
xsubckt_5044_nand3_x0 1 0 3452 40 139 7780 nand3_x0
xsubckt_4605_nand2_x0 1 0 3764 3766 3796 nand2_x0
xsubckt_986_a3_x2 1 6833 0 390 307 229 a3_x2
xsubckt_859_a2_x2 0 6954 1 7143 1837 a2_x2
xsubckt_819_a2_x2 0 6992 1 6993 6997 a2_x2
xsubckt_783_oa22_x2 0 171 1 1737 7039 7027 oa22_x2
xsubckt_422_inv_x0 1 0 751 7369 inv_x0
xsubckt_424_inv_x0 1 0 1679 7367 inv_x0
xsubckt_426_inv_x0 1 0 1615 7365 inv_x0
xsubckt_2216_ao22_x2 0 5735 1 7631 5736 7620 ao22_x2
xsubckt_2300_mx2_x2 0 5653 1 710 1422 1262 mx2_x2
xsubckt_2437_mx3_x2 1 0 5518 707 705 5519 871 1383 mx3_x2
xsubckt_2452_oa22_x2 0 5503 1 1191 7218 5504 oa22_x2
xsubckt_9357_sff1_x4 1 1872 0 9104 1048 sff1_x4
xsubckt_8906_sff1_x4 1 1872 0 9487 1854 sff1_x4
xsubckt_8461_sff1_x4 1 1872 0 9932 725 sff1_x4
xsubckt_7885_mx2_x2 0 8960 1 7817 3878 941 mx2_x2
xsubckt_7883_mx2_x2 0 8962 1 7817 3886 945 mx2_x2
xsubckt_7881_mx2_x2 0 8964 1 7817 3892 967 mx2_x2
xsubckt_7680_nand2_x0 1 0 7849 663 600 nand2_x0
xsubckt_7492_mx2_x2 0 9218 1 7985 441 336 mx2_x2
xsubckt_7490_mx2_x2 0 9220 1 7985 443 338 mx2_x2
xsubckt_7145_mx2_x2 0 9371 1 8166 3878 1293 mx2_x2
xsubckt_7132_nor2_x0 1 0 8172 599 536 nor2_x0
xsubckt_6710_nand2_x0 1 0 1939 1940 712 nand2_x0
xsubckt_6155_ao22_x2 0 9402 1 2482 2484 2515 ao22_x2
xsubckt_4501_nand4_x0 1 0 3772 3783 3901 3903 3906 nand4_x0
xsubckt_4072_nand3_x0 1 0 3912 3913 4074 7104 nand3_x0
xsubckt_3633_nand2_x0 1 0 4343 7153 7265 nand2_x0
xsubckt_3348_oa22_x2 0 4624 1 1566 705 707 oa22_x2
xsubckt_3280_nand3_x0 1 0 4690 4691 4707 5586 nand3_x0
xsubckt_3267_nor2_x0 1 0 4703 4704 704 nor2_x0
xsubckt_1085_nand3_x0 1 0 6738 6739 6740 6741 nand3_x0
xsubckt_744_nand3_x0 1 0 7061 7188 7189 7192 nand3_x0
xsubckt_380_inv_x0 1 0 1526 7411 inv_x0
xsubckt_382_inv_x0 1 0 950 7409 inv_x0
xsubckt_428_inv_x0 1 0 1551 7363 inv_x0
xsubckt_1316_ao22_x2 0 6519 1 6520 6524 7038 ao22_x2
xsubckt_1711_a4_x2 0 6130 1 6234 6245 6304 6310 a4_x2
xsubckt_2260_mx2_x2 0 5692 1 710 1457 1297 mx2_x2
xsubckt_2262_mx2_x2 0 5690 1 7628 5691 5692 mx2_x2
xsubckt_2308_mx2_x2 0 5645 1 711 1166 1102 mx2_x2
xsubckt_9792_sff1_x4 1 1872 0 8684 1686 sff1_x4
xsubckt_9714_sff1_x4 1 1872 0 8762 773 sff1_x4
xsubckt_8892_sff1_x4 1 1872 0 9501 1869 sff1_x4
xsubckt_8457_sff1_x4 1 1872 0 9936 729 sff1_x4
xsubckt_7498_mx2_x2 0 9212 1 7985 435 330 mx2_x2
xsubckt_7496_mx2_x2 0 9214 1 7985 437 332 mx2_x2
xsubckt_7494_mx2_x2 0 9216 1 7985 439 334 mx2_x2
xsubckt_6616_mx2_x2 0 2031 1 712 986 954 mx2_x2
xsubckt_6614_mx2_x2 0 2033 1 712 1146 1114 mx2_x2
xsubckt_6187_nand2_x0 1 0 2450 2451 712 nand2_x0
xsubckt_6042_a2_x2 0 2592 1 7545 710 a2_x2
xsubckt_4878_ao22_x2 0 3576 1 1758 3578 40 ao22_x2
xsubckt_4772_a4_x2 0 3657 1 3658 3671 3707 3711 a4_x2
xsubckt_4689_nand3_x0 1 0 3724 3731 1804 1803 nand3_x0
xsubckt_3705_oa22_x2 0 4272 1 7179 4326 4273 oa22_x2
xsubckt_2657_mx2_x2 0 5302 1 705 1709 877 mx2_x2
xsubckt_384_inv_x0 1 0 853 7407 inv_x0
xsubckt_386_inv_x0 1 0 1429 7405 inv_x0
xsubckt_388_inv_x0 1 0 1269 7403 inv_x0
xsubckt_1203_a2_x2 0 6626 1 217 1739 a2_x2
xsubckt_1421_nxr2_x1 6420 1 0 178 206 nxr2_x1
xsubckt_1955_nand3_x0 1 0 5908 5909 6175 574 nand3_x0
xsubckt_9788_sff1_x4 1 1872 0 8688 1690 sff1_x4
xsubckt_9265_sff1_x4 1 1872 0 9196 303 sff1_x4
xsubckt_8814_sff1_x4 1 1872 0 9579 1753 sff1_x4
xsubckt_7265_a2_x2 0 8121 1 373 372 a2_x2
xsubckt_7128_nor2_x0 1 0 9380 8175 8178 nor2_x0
xsubckt_6965_mx2_x2 0 8333 1 710 755 1619 mx2_x2
xsubckt_6618_mx2_x2 0 2029 1 712 1210 1178 mx2_x2
xsubckt_6586_ao22_x2 0 2060 1 2061 2063 2064 ao22_x2
xsubckt_6574_mx2_x2 0 2072 1 710 2073 2074 mx2_x2
xsubckt_6572_mx2_x2 0 2074 1 712 987 955 mx2_x2
xsubckt_6227_mx2_x2 0 2411 1 710 772 1636 mx2_x2
xsubckt_6097_nand2_x0 1 0 2538 2539 711 nand2_x0
xsubckt_5823_mx3_x2 1 0 2803 7620 712 2804 2806 2807 mx3_x2
xsubckt_5407_a2_x2 0 3117 1 3131 3141 a2_x2
xsubckt_5041_mx3_x2 1 0 3454 5754 518 7781 7298 7299 mx3_x2
xsubckt_4790_ao22_x2 0 3643 1 1781 3645 40 ao22_x2
xsubckt_4029_a2_x2 0 3955 1 3956 7179 a2_x2
xsubckt_3530_a2_x2 0 4445 1 4446 706 a2_x2
xsubckt_3287_a3_x2 1 4683 0 4684 5595 5608 a3_x2
xsubckt_2879_oa22_x2 0 5084 1 1257 705 707 oa22_x2
xsubckt_2747_nand3_x0 1 0 5213 5214 5215 7104 nand3_x0
xsubckt_1511_nand2_x0 1 0 6330 7245 223 nand2_x0
xsubckt_1664_a3_x2 1 6177 0 6365 7226 217 a3_x2
xsubckt_9622_sff1_x4 1 1872 0 8851 862 sff1_x4
xsubckt_8888_sff1_x4 1 1872 0 9505 1815 sff1_x4
xsubckt_8365_sff1_x4 1 1872 0 10020 1564 sff1_x4
xsubckt_7117_oa22_x2 0 8184 1 2729 8187 8185 oa22_x2
xsubckt_6969_mx2_x2 0 8329 1 712 1715 1363 mx2_x2
xsubckt_6576_mx2_x2 0 2070 1 712 1211 1179 mx2_x2
xsubckt_5356_nxr2_x1 3164 1 0 3472 7672 nxr2_x1
xsubckt_4155_nand2_x0 1 0 3845 3848 70 nand2_x0
xsubckt_4065_nand2_x0 1 0 3919 3920 706 nand2_x0
xsubckt_3966_nand4_x0 1 0 4016 5604 532 7689 56 nand4_x0
xsubckt_2481_nand2_x0 1 0 10084 5475 5476 nand2_x0
xsubckt_2466_a2_x2 0 5489 1 701 229 a2_x2
xsubckt_827_nand2_x0 1 0 6985 6986 7047 nand2_x0
xsubckt_1517_a2_x2 0 6324 1 7244 224 a2_x2
xsubckt_1712_a2_x2 0 6129 1 6130 6131 a2_x2
xsubckt_1775_nand3_x0 1 0 6071 6072 6074 6286 nand3_x0
xsubckt_9696_sff1_x4 1 1872 0 8780 790 sff1_x4
xsubckt_9173_sff1_x4 1 1872 0 9285 575 sff1_x4
xsubckt_8722_sff1_x4 1 1872 0 9671 1103 sff1_x4
xsubckt_6877_nand2_x0 1 0 8419 8420 8424 nand2_x0
xsubckt_6494_ao22_x2 0 2150 1 1470 710 712 ao22_x2
xsubckt_5995_nand2_x0 1 0 2638 2639 2646 nand2_x0
xsubckt_5682_a2_x2 0 2909 1 2910 7216 a2_x2
xsubckt_5487_a2_x2 0 9499 1 3053 3054 a2_x2
xsubckt_5110_nand2_x0 1 0 9537 3392 3402 nand2_x0
xsubckt_4793_a2_x2 0 9605 1 3641 3643 a2_x2
xsubckt_4512_mx3_x2 1 0 9756 3773 3897 1094 3859 3860 mx3_x2
xsubckt_4510_mx3_x2 1 0 9758 3773 3897 1066 3867 3868 mx3_x2
xsubckt_3689_a2_x2 0 4288 1 4289 7219 a2_x2
xsubckt_1331_nand2_x0 1 0 6505 588 1787 nand2_x0
xsubckt_1554_xr2_x1 6287 0 1 419 203 xr2_x1
xsubckt_1577_a2_x2 0 6264 1 420 204 a2_x2
xsubckt_1597_a2_x2 0 6244 1 6245 6304 a2_x2
xsubckt_9618_sff1_x4 1 1872 0 8855 866 sff1_x4
xsubckt_9530_sff1_x4 1 1872 0 8936 946 sff1_x4
xsubckt_8796_sff1_x4 1 1872 0 9597 1772 sff1_x4
xsubckt_8718_sff1_x4 1 1872 0 9675 1108 sff1_x4
xsubckt_7025_oa22_x2 0 8275 1 40 1741 178 oa22_x2
xsubckt_4859_o4_x2 0 3590 1 3594 3605 3631 7718 o4_x2
xsubckt_4518_mx3_x2 1 0 9750 3773 3896 1088 3841 3843 mx3_x2
xsubckt_4516_mx3_x2 1 0 9752 3773 3896 1090 3847 3849 mx3_x2
xsubckt_4514_mx3_x2 1 0 9754 3773 3896 1092 3853 3855 mx3_x2
xsubckt_4123_mx3_x2 1 0 10047 3899 3897 1579 3871 3872 mx3_x2
xsubckt_3490_o3_x2 0 4484 1 4485 4486 7216 o3_x2
xsubckt_3179_nand3_x0 1 0 4789 4790 4813 5586 nand3_x0
xsubckt_900_nand2_x0 1 0 6915 587 1775 nand2_x0
xsubckt_794_ao22_x2 0 7016 1 7017 7021 7038 ao22_x2
xsubckt_9526_sff1_x4 1 1872 0 8940 950 sff1_x4
xsubckt_9169_sff1_x4 1 1872 0 9289 591 sff1_x4
xsubckt_9081_sff1_x4 1 1872 0 9345 1295 sff1_x4
xsubckt_8630_sff1_x4 1 1872 0 9763 1073 sff1_x4
xsubckt_8040_mx3_x2 1 0 8813 7810 3896 823 3817 3819 mx3_x2
xsubckt_7298_ao22_x2 0 8099 1 645 7680 585 ao22_x2
xsubckt_7099_oa22_x2 0 8202 1 1423 7625 712 oa22_x2
xsubckt_4476_mx3_x2 1 0 9790 3775 3897 1450 3867 3868 mx3_x2
xsubckt_3271_ao22_x2 0 4699 1 4700 4703 7215 ao22_x2
xsubckt_2903_nand2_x0 1 0 5060 5061 5062 nand2_x0
xsubckt_1233_nxr2_x1 6598 1 0 6600 6601 nxr2_x1
xsubckt_1721_oa22_x2 0 6120 1 6121 6122 6123 oa22_x2
xsubckt_1728_nor2_x0 1 0 6113 591 592 nor2_x0
xsubckt_1768_nand2_x0 1 0 6077 6112 6265 nand2_x0
xsubckt_9003_sff1_x4 1 1872 0 9422 497 sff1_x4
xsubckt_8626_sff1_x4 1 1872 0 9767 1455 sff1_x4
xsubckt_8046_mx3_x2 1 0 8807 7810 3896 816 3799 3801 mx3_x2
xsubckt_8044_mx3_x2 1 0 8809 7810 3896 819 3805 3807 mx3_x2
xsubckt_8042_mx3_x2 1 0 8811 7810 3896 821 3811 3813 mx3_x2
xsubckt_7900_mx3_x2 1 0 8945 7818 3896 955 3829 3831 mx3_x2
xsubckt_6770_nand2_x0 1 0 8524 8525 8529 nand2_x0
xsubckt_6339_nand2_x0 1 0 2302 1665 7625 nand2_x0
xsubckt_6199_oa22_x2 0 2438 1 7631 2439 7628 oa22_x2
xsubckt_4478_mx3_x2 1 0 9788 3775 3897 1478 3859 3860 mx3_x2
xsubckt_3605_nand2_x0 1 0 4371 4372 4377 nand2_x0
xsubckt_3207_mx3_x2 1 0 4762 707 705 4763 1313 1473 mx3_x2
xsubckt_2991_nand2_x0 1 0 4974 4975 704 nand2_x0
xsubckt_2923_o2_x2 0 5041 1 5042 7219 o2_x2
xsubckt_806_nand3_x0 1 0 7005 7006 7008 7009 nand3_x0
xsubckt_1272_oa22_x2 0 6561 1 392 7044 6880 oa22_x2
xsubckt_9434_sff1_x4 1 1872 0 9032 1359 sff1_x4
xsubckt_9077_sff1_x4 1 1872 0 9349 1300 sff1_x4
xsubckt_8262_mx2_x2 0 9250 1 5752 9078 651 mx2_x2
xsubckt_8260_mx2_x2 0 9252 1 5752 9080 653 mx2_x2
xsubckt_7906_mx3_x2 1 0 8939 7818 3896 949 3811 3813 mx3_x2
xsubckt_7904_mx3_x2 1 0 8941 7818 3896 951 3817 3819 mx3_x2
xsubckt_7902_mx3_x2 1 0 8943 7818 3896 953 3823 3825 mx3_x2
xsubckt_7472_nand2_x0 1 0 7988 7989 2858 nand2_x0
xsubckt_6680_nand2_x0 1 0 1968 1969 712 nand2_x0
xsubckt_6502_nand2_x0 1 0 2142 2143 7631 nand2_x0
xsubckt_5710_nand2_x0 1 0 2881 2882 704 nand2_x0
xsubckt_5620_nand2_x0 1 0 2956 2959 1827 nand2_x0
xsubckt_3624_ao22_x2 0 4352 1 7437 7217 707 ao22_x2
xsubckt_3421_mx2_x2 0 4552 1 7219 4553 4554 mx2_x2
xsubckt_3209_mx3_x2 1 0 4760 707 705 4761 1249 1409 mx3_x2
xsubckt_3072_nand3_x0 1 0 4894 4895 4913 5586 nand3_x0
xsubckt_2983_o2_x2 0 4982 1 4983 4985 o2_x2
xsubckt_1220_nand3_x0 1 0 6610 6611 6612 6613 nand3_x0
xsubckt_1841_nand2_x0 1 0 6011 6114 6238 nand2_x0
xsubckt_8534_sff1_x4 1 1872 0 9859 1489 sff1_x4
xsubckt_8266_mx2_x2 0 9246 1 5752 9073 647 mx2_x2
xsubckt_8264_mx2_x2 0 9248 1 5752 9075 649 mx2_x2
xsubckt_7908_mx3_x2 1 0 8937 7818 3896 947 3805 3807 mx3_x2
xsubckt_7862_mx3_x2 1 0 8981 7820 3896 1184 3841 3843 mx3_x2
xsubckt_7860_mx3_x2 1 0 8983 7820 3896 1186 3847 3849 mx3_x2
xsubckt_7040_ao22_x2 0 8260 1 8271 8273 708 ao22_x2
xsubckt_5332_ao22_x2 0 3187 1 3201 3197 3189 ao22_x2
xsubckt_4180_nxr2_x1 3826 1 0 3830 63 nxr2_x1
xsubckt_3499_oa22_x2 0 4475 1 4497 4483 4476 oa22_x2
xsubckt_3427_mx2_x2 0 4546 1 707 4547 4548 mx2_x2
xsubckt_3425_mx2_x2 0 4548 1 705 1181 1053 mx2_x2
xsubckt_3038_mx2_x2 0 4928 1 705 772 1636 mx2_x2
xsubckt_2960_oa22_x2 0 5004 1 5024 5012 5005 oa22_x2
xsubckt_1102_oa22_x2 0 6722 1 402 7042 6725 oa22_x2
xsubckt_717_a2_x2 0 7085 1 7100 7690 a2_x2
xsubckt_9865_sff1_x4 1 1872 0 8611 1628 sff1_x4
xsubckt_9342_sff1_x4 1 1872 0 9119 1034 sff1_x4
xsubckt_7868_mx3_x2 1 0 8975 7820 3896 1177 3823 3825 mx3_x2
xsubckt_7866_mx3_x2 1 0 8977 7820 3896 1179 3829 3831 mx3_x2
xsubckt_7864_mx3_x2 1 0 8979 7820 3896 1182 3835 3837 mx3_x2
xsubckt_6383_nor2_x0 1 0 2258 2259 7134 nor2_x0
xsubckt_5440_nand2_x0 1 0 3086 3087 3089 nand2_x0
xsubckt_3778_mx2_x2 0 4201 1 705 1686 1558 mx2_x2
xsubckt_3776_mx2_x2 0 4203 1 705 758 1622 mx2_x2
xsubckt_3387_mx2_x2 0 4585 1 705 1502 1342 mx2_x2
xsubckt_3245_nand2_x0 1 0 4725 222 694 nand2_x0
xsubckt_2503_mx2_x2 0 5453 1 707 5454 5455 mx2_x2
xsubckt_2501_mx2_x2 0 5455 1 705 732 1596 mx2_x2
xsubckt_977_nand2_x0 1 0 6842 700 75 nand2_x0
xsubckt_972_a2_x2 0 6846 1 199 1739 a2_x2
xsubckt_932_a2_x2 0 6885 1 6886 6887 a2_x2
xsubckt_230_inv_x0 1 0 1547 7561 inv_x0
xsubckt_232_inv_x0 1 0 1451 7559 inv_x0
xsubckt_234_inv_x0 1 0 1291 7557 inv_x0
xsubckt_1571_nand2_x0 1 0 6270 423 7292 nand2_x0
xsubckt_2241_mx3_x2 1 0 5710 712 710 5711 1596 732 mx3_x2
xsubckt_2453_nand2_x0 1 0 5502 7218 1063 nand2_x0
xsubckt_8965_sff1_x4 1 1872 0 161 98 sff1_x4
xsubckt_8442_sff1_x4 1 1872 0 9951 715 sff1_x4
xsubckt_7436_a4_x2 0 8014 1 8155 8156 9095 9094 a4_x2
xsubckt_6939_nand2_x0 1 0 8358 8359 8364 nand2_x0
xsubckt_6318_nand3_x0 1 0 2322 2323 2330 7613 nand3_x0
xsubckt_6136_ao22_x2 0 2500 1 2501 2509 711 ao22_x2
xsubckt_5436_nand3_x0 1 0 3090 3092 3093 3102 nand3_x0
xsubckt_4176_nxr2_x1 3829 1 0 3833 64 nxr2_x1
xsubckt_3764_oa22_x2 0 4215 1 4269 4264 4268 oa22_x2
xsubckt_3389_mx2_x2 0 4583 1 705 1726 894 mx2_x2
xsubckt_3246_xr2_x1 4724 0 1 222 694 xr2_x1
xsubckt_3155_nand2_x0 1 0 4813 4814 4815 nand2_x0
xsubckt_581_inv_x0 1 0 520 7210 inv_x0
xsubckt_190_inv_x0 1 0 1607 7601 inv_x0
xsubckt_236_inv_x0 1 0 939 7555 inv_x0
xsubckt_238_inv_x0 1 0 906 7553 inv_x0
xsubckt_9773_sff1_x4 1 1872 0 8703 1676 sff1_x4
xsubckt_9338_sff1_x4 1 1872 0 9123 1038 sff1_x4
xsubckt_9250_sff1_x4 1 1872 0 9211 328 sff1_x4
xsubckt_8438_sff1_x4 1 1872 0 9955 721 sff1_x4
xsubckt_7693_mx2_x2 0 9162 1 8139 7839 679 mx2_x2
xsubckt_7627_nand4_x0 1 0 7892 7893 7951 7957 8140 nand4_x0
xsubckt_7268_oa22_x2 0 9302 1 604 8138 8119 oa22_x2
xsubckt_7123_a2_x2 0 8179 1 8181 2829 a2_x2
xsubckt_6817_oa22_x2 0 8478 1 8479 8486 7620 oa22_x2
xsubckt_6557_mx3_x2 1 0 2088 712 710 2089 7470 7472 mx3_x2
xsubckt_6422_mx2_x2 0 2220 1 708 2221 2223 mx2_x2
xsubckt_6420_mx2_x2 0 2222 1 710 1024 832 mx2_x2
xsubckt_6291_nor2_x0 1 0 2348 2349 7134 nor2_x0
xsubckt_6031_mx2_x2 0 2603 1 710 2604 2605 mx2_x2
xsubckt_5638_a4_x2 0 2943 1 2951 1821 1822 1823 a4_x2
xsubckt_5432_a3_x2 1 3094 0 40 7780 115 a3_x2
xsubckt_5365_nor3_x0 1 0 3156 3157 3162 3166 nor3_x0
xsubckt_4749_a4_x2 0 3675 1 1794 1793 1792 1791 a4_x2
xsubckt_4074_a3_x2 1 3910 0 3911 3912 3914 a3_x2
xsubckt_3241_oa22_x2 0 4729 1 4833 4777 4778 oa22_x2
xsubckt_1073_a3_x2 1 6750 0 6751 6756 6771 a3_x2
xsubckt_797_nand2_x0 1 0 7013 701 76 nand2_x0
xsubckt_605_nor2_x0 1 0 7186 598 593 nor2_x0
xsubckt_196_inv_x0 1 0 1340 7595 inv_x0
xsubckt_194_inv_x0 1 0 701 7597 inv_x0
xsubckt_192_inv_x0 1 0 999 7599 inv_x0
xsubckt_1925_nxr2_x1 5935 1 0 5936 6342 nxr2_x1
xsubckt_2341_oa22_x2 0 5612 1 5613 5634 5744 oa22_x2
xsubckt_9769_sff1_x4 1 1872 0 8707 1692 sff1_x4
xsubckt_8873_sff1_x4 1 1872 0 9520 124 sff1_x4
xsubckt_8350_sff1_x4 1 1872 0 10035 1597 sff1_x4
xsubckt_7699_mx2_x2 0 9161 1 8139 7834 690 mx2_x2
xsubckt_7417_a2_x2 0 9260 1 8020 8115 a2_x2
xsubckt_7349_a3_x2 1 8060 0 8067 7679 644 a3_x2
xsubckt_6773_mx2_x2 0 8521 1 710 1015 823 mx2_x2
xsubckt_6567_ao22_x2 0 2078 1 534 532 691 ao22_x2
xsubckt_6035_mx2_x2 0 2599 1 710 1674 1546 mx2_x2
xsubckt_5787_nand2_x0 1 0 2836 2837 2839 nand2_x0
xsubckt_5609_nand2_x0 1 0 2964 2967 1830 nand2_x0
xsubckt_5520_a2_x2 0 9490 1 3029 3030 a2_x2
xsubckt_5472_a3_x2 1 9503 0 3064 3065 40 a3_x2
xsubckt_3959_ao22_x2 0 4023 1 4024 4027 7215 ao22_x2
xsubckt_3672_oa22_x2 0 4305 1 4306 705 7219 oa22_x2
xsubckt_3213_a2_x2 0 4756 1 4757 7217 a2_x2
xsubckt_3185_a3_x2 1 4783 0 4784 4785 4787 a3_x2
xsubckt_2783_nor2_x0 1 0 5178 5179 707 nor2_x0
xsubckt_765_o2_x2 0 7043 1 308 307 o2_x2
xsubckt_198_inv_x0 1 0 1084 7593 inv_x0
xsubckt_1283_ao22_x2 0 6551 1 6569 6564 6566 ao22_x2
xsubckt_1448_nor2_x0 1 0 6393 181 210 nor2_x0
xsubckt_1476_nxr2_x1 6365 1 0 187 216 nxr2_x1
xsubckt_2093_nand2_x0 1 0 5785 198 307 nand2_x0
xsubckt_2109_a2_x2 0 5772 1 5773 5774 a2_x2
xsubckt_2348_nor2_x0 1 0 5606 1739 1741 nor2_x0
xsubckt_9681_sff1_x4 1 1872 0 8795 806 sff1_x4
xsubckt_9603_sff1_x4 1 1872 0 8870 911 sff1_x4
xsubckt_9246_sff1_x4 1 1872 0 9215 333 sff1_x4
xsubckt_8869_sff1_x4 1 1872 0 9524 129 sff1_x4
xsubckt_8346_sff1_x4 1 1872 0 10039 1601 sff1_x4
xsubckt_7437_a2_x2 0 8013 1 8152 8153 a2_x2
xsubckt_6929_a3_x2 1 8368 0 8369 8383 7620 a3_x2
xsubckt_6548_a2_x2 0 2097 1 7475 710 a2_x2
xsubckt_6401_ao22_x2 0 2241 1 2242 2244 2245 ao22_x2
xsubckt_5796_nor3_x0 1 0 2829 1739 1741 1737 nor3_x0
xsubckt_5697_nand2_x0 1 0 2894 707 7360 nand2_x0
xsubckt_5619_a2_x2 0 9463 1 2957 2958 a2_x2
xsubckt_3565_nor3_x0 1 0 4410 4411 4436 5585 nor3_x0
xsubckt_3098_a2_x2 0 4869 1 4870 7215 a2_x2
xsubckt_780_nand2_x0 1 0 7029 1739 230 nand2_x0
xsubckt_1650_a2_x2 0 6191 1 6192 6195 a2_x2
xsubckt_1836_a3_x2 1 6016 0 6025 6308 6311 a3_x2
xsubckt_2432_nand3_x0 1 0 5523 5524 5529 704 nand3_x0
xsubckt_9677_sff1_x4 1 1872 0 8799 780 sff1_x4
xsubckt_8781_sff1_x4 1 1872 0 9612 1789 sff1_x4
xsubckt_8703_sff1_x4 1 1872 0 9690 1124 sff1_x4
xsubckt_7946_a2_x2 0 7814 1 3787 3904 a2_x2
xsubckt_7534_nand2_x0 1 0 9194 7966 7967 nand2_x0
xsubckt_6742_nand2_x0 1 0 8551 8552 712 nand2_x0
xsubckt_6388_mx2_x2 0 2254 1 712 1152 1120 mx2_x2
xsubckt_5899_oa22_x2 0 2731 1 7082 5612 2732 oa22_x2
xsubckt_5851_mx2_x2 0 2776 1 7625 7607 7611 mx2_x2
xsubckt_5376_oa22_x2 0 3146 1 7680 3466 7167 oa22_x2
xsubckt_4800_nand2_x0 1 0 3636 3637 7710 nand2_x0
xsubckt_4320_mx3_x2 1 0 9932 3789 3896 725 3811 3813 mx3_x2
xsubckt_4082_o3_x2 0 3903 1 519 520 521 o3_x2
xsubckt_3867_ao22_x2 0 4114 1 4165 4160 4162 ao22_x2
xsubckt_2959_nand3_x0 1 0 5005 5006 5595 5608 nand3_x0
xsubckt_866_nand3_x0 1 0 145 6948 6956 6962 nand3_x0
xsubckt_587_nor2_x0 1 0 7204 482 483 nor2_x0
xsubckt_1495_a2_x2 0 6346 1 189 219 a2_x2
xsubckt_1903_nand2_x0 1 0 5955 6112 6357 nand2_x0
xsubckt_9511_sff1_x4 1 1872 0 8955 966 sff1_x4
xsubckt_9154_sff1_x4 1 1872 0 9304 605 sff1_x4
xsubckt_8777_sff1_x4 1 1872 0 9616 1793 sff1_x4
xsubckt_7529_oa22_x2 0 7969 1 7970 7093 7212 oa22_x2
xsubckt_7430_nand4_x0 1 0 8019 348 531 7679 644 nand4_x0
xsubckt_5894_a2_x2 0 2735 1 7134 423 a2_x2
xsubckt_5857_mx2_x2 0 2770 1 710 775 1639 mx2_x2
xsubckt_5856_nand3_x0 1 0 2771 2772 2773 7620 nand3_x0
xsubckt_5333_o2_x2 0 3186 1 3187 7690 o2_x2
xsubckt_4999_oa22_x2 0 9554 1 7168 3486 3488 oa22_x2
xsubckt_4324_mx3_x2 1 0 9928 3789 3896 720 3799 3801 mx3_x2
xsubckt_4322_mx3_x2 1 0 9930 3789 3896 723 3805 3807 mx3_x2
xsubckt_3221_o2_x2 0 4748 1 4749 4751 o2_x2
xsubckt_2693_nand2_x0 1 0 5266 7153 7290 nand2_x0
xsubckt_1345_oa22_x2 0 6492 1 6515 6510 6513 oa22_x2
xsubckt_1829_nxr2_x1 6022 1 0 6023 6310 nxr2_x1
xsubckt_1868_oa22_x2 0 5987 1 6318 6007 5988 oa22_x2
xsubckt_2312_o2_x2 0 5641 1 5642 5644 o2_x2
xsubckt_9585_sff1_x4 1 1872 0 8888 931 sff1_x4
xsubckt_9062_sff1_x4 1 1872 0 9364 1316 sff1_x4
xsubckt_8611_sff1_x4 1 1872 0 9782 1472 sff1_x4
xsubckt_8241_mx3_x2 1 0 8592 7798 3896 1626 3826 3828 mx3_x2
xsubckt_7441_oa22_x2 0 8010 1 644 7679 7675 oa22_x2
xsubckt_7264_nand2_x0 1 0 9303 8122 8123 nand2_x0
xsubckt_5802_o2_x2 0 2824 1 2825 709 o2_x2
xsubckt_5412_nand2_x0 1 0 3112 3459 665 nand2_x0
xsubckt_5373_o2_x2 0 3148 1 3149 3150 o2_x2
xsubckt_5069_nand2_x0 1 0 3429 3430 3431 nand2_x0
xsubckt_4542_mx2_x2 0 9728 1 3770 3874 1420 mx2_x2
xsubckt_4540_mx2_x2 0 9730 1 3770 3882 1422 mx2_x2
xsubckt_4284_mx3_x2 1 0 9965 3792 3896 886 3814 3816 mx3_x2
xsubckt_4282_mx3_x2 1 0 9967 3792 3896 888 3820 3822 mx3_x2
xsubckt_4280_mx3_x2 1 0 9969 3792 3896 890 3826 3828 mx3_x2
xsubckt_1248_o2_x2 0 6584 1 686 61 o2_x2
xsubckt_1264_nor2_x0 1 0 6569 685 60 nor2_x0
xsubckt_1463_o2_x2 0 6378 1 185 214 o2_x2
xsubckt_1719_nand3_x0 1 0 6122 6145 6197 7220 nand3_x0
xsubckt_2425_nand2_x0 1 0 5530 5531 707 nand2_x0
xsubckt_9507_sff1_x4 1 1872 0 8959 940 sff1_x4
xsubckt_8685_sff1_x4 1 1872 0 9708 1429 sff1_x4
xsubckt_8245_mx3_x2 1 0 8588 7798 3896 1622 3814 3816 mx3_x2
xsubckt_8243_mx3_x2 1 0 8590 7798 3896 1624 3820 3822 mx3_x2
xsubckt_6292_nand2_x0 1 0 2347 2348 2350 nand2_x0
xsubckt_6114_nand2_x0 1 0 2521 2522 2527 nand2_x0
xsubckt_5687_o2_x2 0 2904 1 2905 2909 o2_x2
xsubckt_5534_nor3_x0 1 0 9486 3019 3020 7702 nor3_x0
xsubckt_5153_nxr2_x1 3352 1 0 3353 3356 nxr2_x1
xsubckt_4288_mx3_x2 1 0 9961 3792 3896 882 3802 3804 mx3_x2
xsubckt_4286_mx3_x2 1 0 9963 3792 3896 884 3808 3810 mx3_x2
xsubckt_3127_nand2_x0 1 0 4840 7152 7269 nand2_x0
xsubckt_3049_oa22_x2 0 4917 1 4918 705 7219 oa22_x2
xsubckt_2510_oa22_x2 0 5446 1 988 705 707 oa22_x2
xsubckt_1253_oa22_x2 0 6579 1 393 7044 6880 oa22_x2
xsubckt_1539_nand3_x0 1 0 6302 6304 7238 200 nand3_x0
xsubckt_1737_o2_x2 0 1936 1 6105 6118 o2_x2
xsubckt_1776_oa22_x2 0 6070 1 6072 6074 6286 oa22_x2
xsubckt_9493_sff1_x4 1 1872 0 8973 1175 sff1_x4
xsubckt_9058_sff1_x4 1 1872 0 9368 1290 sff1_x4
xsubckt_8607_sff1_x4 1 1872 0 9786 1476 sff1_x4
xsubckt_8249_mx3_x2 1 0 8584 7798 3896 1618 3802 3804 mx3_x2
xsubckt_8247_mx3_x2 1 0 8586 7798 3896 1620 3808 3810 mx3_x2
xsubckt_8118_mx2_x2 0 8709 1 7803 3894 1704 mx2_x2
xsubckt_7636_ao22_x2 0 7885 1 607 594 372 ao22_x2
xsubckt_7084_nand2_x0 1 0 8217 8218 8219 nand2_x0
xsubckt_5192_oa22_x2 0 3316 1 3333 3331 3332 oa22_x2
xsubckt_3929_oa22_x2 0 4053 1 704 4054 703 oa22_x2
xsubckt_3683_ao22_x2 0 4294 1 792 7217 4295 ao22_x2
xsubckt_3620_mx2_x2 0 4356 1 705 1177 1049 mx2_x2
xsubckt_3406_oa22_x2 0 4567 1 4632 4631 4630 oa22_x2
xsubckt_3160_ao22_x2 0 4808 1 834 7217 7219 ao22_x2
xsubckt_3037_nand2_x0 1 0 4929 4930 707 nand2_x0
xsubckt_1610_oa22_x2 0 6231 1 6309 6302 6232 oa22_x2
xsubckt_1970_nand3_x0 1 0 5894 5895 5896 5897 nand3_x0
xsubckt_1975_ao22_x2 0 5889 1 5890 5891 5892 ao22_x2
xsubckt_2061_oa22_x2 0 5811 1 5820 6422 6425 oa22_x2
xsubckt_9850_sff1_x4 1 1872 0 8626 1245 sff1_x4
xsubckt_9415_sff1_x4 1 1872 0 9051 1380 sff1_x4
xsubckt_8593_sff1_x4 1 1872 0 9800 1008 sff1_x4
xsubckt_8515_sff1_x4 1 1872 0 9878 992 sff1_x4
xsubckt_7718_mx3_x2 1 0 9147 7830 3896 1348 3853 3855 mx3_x2
xsubckt_7716_mx3_x2 1 0 9149 7830 3897 1350 3859 3860 mx3_x2
xsubckt_7333_nand3_x0 1 0 8072 8076 8097 8133 nand3_x0
xsubckt_5114_oa22_x2 0 3388 1 7690 3389 7680 oa22_x2
xsubckt_3907_nand2_x0 1 0 4074 7152 7254 nand2_x0
xsubckt_2848_nand4_x0 1 0 5114 5604 532 7689 47 nand4_x0
xsubckt_2831_mx3_x2 1 0 5131 707 705 5132 1034 1162 mx3_x2
xsubckt_1005_nand2_x0 1 0 6815 6818 6836 nand2_x0
xsubckt_694_nor4_x0 1 0 7107 41 43 42 45 nor4_x0
xsubckt_679_nand2_x0 1 0 10105 7121 7133 nand2_x0
xsubckt_9846_sff1_x4 1 1872 0 8630 1249 sff1_x4
xsubckt_9489_sff1_x4 1 1872 0 8977 1179 sff1_x4
xsubckt_8950_sff1_x4 1 1872 0 148 85 sff1_x4
xsubckt_8589_sff1_x4 1 1872 0 9804 1013 sff1_x4
xsubckt_7021_ao22_x2 0 8278 1 8279 8294 2729 ao22_x2
xsubckt_6968_oa22_x2 0 8330 1 8331 8336 8343 oa22_x2
xsubckt_6802_oa22_x2 0 8493 1 40 1741 183 oa22_x2
xsubckt_5387_ao22_x2 0 3135 1 3140 3139 3136 ao22_x2
xsubckt_3586_mx2_x2 0 4390 1 705 1465 1305 mx2_x2
xsubckt_3584_mx2_x2 0 4392 1 705 1497 1337 mx2_x2
xsubckt_1118_nxr2_x1 6707 1 0 694 69 nxr2_x1
xsubckt_695_a2_x2 0 7106 1 7107 7683 a2_x2
xsubckt_431_inv_x0 1 0 1391 7360 inv_x0
xsubckt_433_inv_x0 1 0 1135 7358 inv_x0
xsubckt_9323_sff1_x4 1 1872 0 9138 1338 sff1_x4
xsubckt_8946_sff1_x4 1 1872 0 9447 205 sff1_x4
xsubckt_8423_sff1_x4 1 1872 0 9970 891 sff1_x4
xsubckt_7684_nand2_x0 1 0 7846 8018 360 nand2_x0
xsubckt_7452_ao22_x2 0 8002 1 8009 8074 537 ao22_x2
xsubckt_6714_nand2_x0 1 0 8579 8580 7631 nand2_x0
xsubckt_5980_oa22_x2 0 2653 1 40 1741 417 oa22_x2
xsubckt_5309_ao22_x2 0 3208 1 644 3480 7168 ao22_x2
xsubckt_5262_a4_x2 0 3252 1 3281 3489 3492 3495 a4_x2
xsubckt_5096_oa22_x2 0 3404 1 7087 3406 3405 oa22_x2
xsubckt_5057_nxr2_x1 3440 1 0 3441 3450 nxr2_x1
xsubckt_4138_a4_x2 0 3858 1 3869 46 75 74 a4_x2
xsubckt_3587_ao22_x2 0 4389 1 7219 4390 703 ao22_x2
xsubckt_3513_ao22_x2 0 4462 1 7446 705 706 ao22_x2
xsubckt_3199_mx2_x2 0 4770 1 705 929 801 mx2_x2
xsubckt_2708_mx2_x2 0 5252 1 705 1004 812 mx2_x2
xsubckt_2660_mx2_x2 0 5299 1 705 909 781 mx2_x2
xsubckt_1076_nor2_x0 1 0 6747 6750 7791 nor2_x0
xsubckt_949_a2_x2 0 6868 1 200 1739 a2_x2
xsubckt_435_inv_x0 1 0 943 7356 inv_x0
xsubckt_437_inv_x0 1 0 1881 7354 inv_x0
xsubckt_439_inv_x0 1 0 1878 7352 inv_x0
xsubckt_1963_nand2_x0 1 0 5900 6114 6374 nand2_x0
xsubckt_2313_mx2_x2 0 5640 1 711 1198 1134 mx2_x2
xsubckt_2315_mx2_x2 0 5638 1 711 1070 974 mx2_x2
xsubckt_9754_sff1_x4 1 1872 0 8722 1725 sff1_x4
xsubckt_9397_sff1_x4 1 1872 0 9064 352 sff1_x4
xsubckt_9319_sff1_x4 1 1872 0 9142 1343 sff1_x4
xsubckt_8497_sff1_x4 1 1872 0 9896 1520 sff1_x4
xsubckt_6623_mx2_x2 0 2024 1 710 1690 1562 mx2_x2
xsubckt_6353_oa22_x2 0 2288 1 2289 2296 7620 oa22_x2
xsubckt_6232_mx2_x2 0 2406 1 710 1476 1316 mx2_x2
xsubckt_6117_ao22_x2 0 2518 1 534 532 671 ao22_x2
xsubckt_6018_mx3_x2 1 0 2615 708 7631 2616 2618 2619 mx3_x2
xsubckt_5604_a3_x2 1 9467 0 2968 2969 40 a3_x2
xsubckt_5155_a3_x2 1 3350 0 3373 3516 3519 a3_x2
xsubckt_4844_ao22_x2 0 3602 1 1767 3603 40 ao22_x2
xsubckt_4000_a2_x2 0 3983 1 3984 7217 a2_x2
xsubckt_3944_ao22_x2 0 4038 1 4039 4052 7218 ao22_x2
xsubckt_3547_nand2_x0 1 0 4428 7218 890 nand2_x0
xsubckt_2662_mx2_x2 0 5297 1 707 5298 5299 mx2_x2
xsubckt_603_o2_x2 0 7188 1 595 596 o2_x2
xsubckt_391_inv_x0 1 0 852 7400 inv_x0
xsubckt_393_inv_x0 1 0 1428 7398 inv_x0
xsubckt_395_inv_x0 1 0 1268 7396 inv_x0
xsubckt_1549_nxr2_x1 6292 1 0 418 202 nxr2_x1
xsubckt_1873_nand2_x0 1 0 5982 6114 6208 nand2_x0
xsubckt_9231_sff1_x4 1 1872 0 9230 340 sff1_x4
xsubckt_8854_sff1_x4 1 1872 0 9539 114 sff1_x4
xsubckt_8419_sff1_x4 1 1872 0 9974 896 sff1_x4
xsubckt_8331_sff1_x4 1 1872 0 10054 1608 sff1_x4
xsubckt_7041_a2_x2 0 8259 1 8260 8266 a2_x2
xsubckt_6970_mx2_x2 0 8328 1 712 883 851 mx2_x2
xsubckt_6627_mx2_x2 0 2020 1 711 2021 2023 mx2_x2
xsubckt_6625_mx2_x2 0 2022 1 710 762 1626 mx2_x2
xsubckt_6581_mx2_x2 0 2065 1 710 1691 1563 mx2_x2
xsubckt_6349_oa22_x2 0 2292 1 993 710 712 oa22_x2
xsubckt_6238_mx2_x2 0 2400 1 710 1444 1284 mx2_x2
xsubckt_6234_mx2_x2 0 2404 1 712 2405 2406 mx2_x2
xsubckt_5469_a3_x2 1 3066 0 3071 1809 1810 a3_x2
xsubckt_5390_a3_x2 1 3133 0 40 119 7780 a3_x2
xsubckt_3171_a2_x2 0 4797 1 4798 706 a2_x2
xsubckt_2918_xr2_x1 5046 0 1 228 700 xr2_x1
xsubckt_1065_oa22_x2 0 6757 1 1737 6766 6758 oa22_x2
xsubckt_937_o2_x2 0 6880 1 524 525 o2_x2
xsubckt_854_mx2_x2 0 6959 1 229 405 388 mx2_x2
xsubckt_397_inv_x0 1 0 1204 7394 inv_x0
xsubckt_399_inv_x0 1 0 1076 7392 inv_x0
xsubckt_1714_a3_x2 1 6127 0 6128 6255 6262 a3_x2
xsubckt_1783_nand2_x0 1 0 6064 6116 6293 nand2_x0
xsubckt_1787_ao22_x2 0 6060 1 6075 6288 6289 ao22_x2
xsubckt_1945_oa22_x2 0 5917 1 6361 5927 5918 oa22_x2
xsubckt_2047_a2_x2 0 5823 1 6114 6410 a2_x2
xsubckt_2277_mx2_x2 0 5675 1 710 1009 817 mx2_x2
xsubckt_2279_mx2_x2 0 5673 1 710 1713 881 mx2_x2
xsubckt_9662_sff1_x4 1 1872 0 8814 824 sff1_x4
xsubckt_9227_sff1_x4 1 1872 0 9234 480 sff1_x4
xsubckt_7355_a2_x2 0 8056 1 8138 579 a2_x2
xsubckt_6978_mx2_x2 0 8320 1 710 1427 1267 mx2_x2
xsubckt_6974_mx2_x2 0 8324 1 712 819 787 mx2_x2
xsubckt_6641_a2_x2 0 2006 1 7453 710 a2_x2
xsubckt_6264_nand2_x0 1 0 2375 2376 712 nand2_x0
xsubckt_5705_mx2_x2 0 2886 1 7217 7364 7368 mx2_x2
xsubckt_5703_mx2_x2 0 2888 1 7217 7373 7377 mx2_x2
xsubckt_5558_nand3_x0 1 0 3001 3007 1846 1845 nand3_x0
xsubckt_5449_oa22_x2 0 3080 1 1871 1870 1859 oa22_x2
xsubckt_4766_nand3_x0 1 0 3661 3667 1789 1788 nand3_x0
xsubckt_3367_nand2_x0 1 0 4605 705 1054 nand2_x0
xsubckt_3191_a2_x2 0 4778 1 223 695 a2_x2
xsubckt_2536_a2_x2 0 5420 1 218 690 a2_x2
xsubckt_2516_a2_x2 0 5440 1 5441 5442 a2_x2
xsubckt_1429_nor2_x0 1 0 6412 179 208 nor2_x0
xsubckt_1627_a2_x2 0 6214 1 6215 6218 a2_x2
xsubckt_2307_nand2_x0 1 0 5646 5647 5651 nand2_x0
xsubckt_8762_sff1_x4 1 1872 0 9631 1751 sff1_x4
xsubckt_8327_sff1_x4 1 1872 0 10058 210 sff1_x4
xsubckt_7844_a2_x2 0 7820 1 3769 3900 a2_x2
xsubckt_6955_a2_x2 0 8343 1 8344 8345 a2_x2
xsubckt_6915_a2_x2 0 8382 1 7399 710 a2_x2
xsubckt_6198_mx2_x2 0 2439 1 710 1157 997 mx2_x2
xsubckt_5707_mx2_x2 0 2884 1 707 2885 2886 mx2_x2
xsubckt_5597_a2_x2 0 9469 1 2973 2974 a2_x2
xsubckt_5318_nxr2_x1 3200 1 0 3478 665 nxr2_x1
xsubckt_4863_a2_x2 0 9588 1 3588 3589 a2_x2
xsubckt_4668_a2_x2 0 3740 1 1751 1746 a2_x2
xsubckt_4660_ao22_x2 0 3746 1 1762 3752 40 ao22_x2
xsubckt_4648_a2_x2 0 9635 1 3756 3757 a2_x2
xsubckt_4026_oa22_x2 0 3958 1 4010 4005 4008 oa22_x2
xsubckt_3914_a2_x2 0 10058 1 4068 4115 a2_x2
xsubckt_3440_nand2_x0 1 0 4533 7153 7268 nand2_x0
xsubckt_2952_ao22_x2 0 5012 1 7216 5013 5586 ao22_x2
xsubckt_848_ao22_x2 0 6965 1 6981 6980 6979 ao22_x2
xsubckt_9658_sff1_x4 1 1872 0 8818 829 sff1_x4
xsubckt_9570_sff1_x4 1 1872 0 8903 1200 sff1_x4
xsubckt_9135_sff1_x4 1 1872 0 9323 1149 sff1_x4
xsubckt_8758_sff1_x4 1 1872 0 9635 1795 sff1_x4
xsubckt_6513_nand3_x0 1 0 2131 2132 2146 7620 nand3_x0
xsubckt_4525_mx3_x2 1 0 9743 3773 3896 1080 3820 3822 mx3_x2
xsubckt_4523_mx3_x2 1 0 9745 3773 3896 1082 3826 3828 mx3_x2
xsubckt_4521_mx3_x2 1 0 9747 3773 3896 1085 3832 3834 mx3_x2
xsubckt_4001_mx2_x2 0 3982 1 706 1042 946 mx2_x2
xsubckt_2037_nand2_x0 1 0 5832 6112 6417 nand2_x0
xsubckt_8670_sff1_x4 1 1872 0 9723 1445 sff1_x4
xsubckt_7589_o3_x2 0 7923 1 7924 7952 7955 o3_x2
xsubckt_7569_o3_x2 0 7938 1 7939 7952 7955 o3_x2
xsubckt_5271_o2_x2 0 3243 1 3244 3253 o2_x2
xsubckt_5198_nand3_x0 1 0 3311 40 134 7780 nand3_x0
xsubckt_4849_nand2_x0 1 0 3598 3601 1766 nand2_x0
xsubckt_4529_mx3_x2 1 0 9739 3773 3896 1076 3808 3810 mx3_x2
xsubckt_4527_mx3_x2 1 0 9741 3773 3896 1078 3814 3816 mx3_x2
xsubckt_4483_mx3_x2 1 0 9783 3775 3896 1473 3844 3846 mx3_x2
xsubckt_4481_mx3_x2 1 0 9785 3775 3896 1475 3850 3852 mx3_x2
xsubckt_4007_mx2_x2 0 3976 1 705 754 1618 mx2_x2
xsubckt_4005_mx2_x2 0 3978 1 705 1682 1554 mx2_x2
xsubckt_3402_nor2_x0 1 0 4570 4571 4573 nor2_x0
xsubckt_3278_o2_x2 0 4692 1 4693 4699 o2_x2
xsubckt_3260_nand2_x0 1 0 4710 4716 7215 nand2_x0
xsubckt_992_nand2_x0 1 0 6827 588 1805 nand2_x0
xsubckt_914_oa22_x2 0 6902 1 7050 7053 7282 oa22_x2
xsubckt_814_nand2_x0 1 0 6997 7143 1859 nand2_x0
xsubckt_1341_o2_x2 0 6496 1 681 56 o2_x2
xsubckt_1761_oa22_x2 0 6083 1 6134 6084 6085 oa22_x2
xsubckt_2349_o2_x2 0 5605 1 1739 1741 o2_x2
xsubckt_9566_sff1_x4 1 1872 0 8907 1205 sff1_x4
xsubckt_9043_sff1_x4 1 1872 0 9383 179 sff1_x4
xsubckt_8666_sff1_x4 1 1872 0 9727 1419 sff1_x4
xsubckt_7695_ao22_x2 0 7837 1 536 531 346 ao22_x2
xsubckt_5464_ao22_x2 0 3069 1 3074 1815 40 ao22_x2
xsubckt_4745_nand4_x0 1 0 3678 3685 1794 1793 1792 nand4_x0
xsubckt_4489_mx3_x2 1 0 9777 3775 3896 1466 3826 3828 mx3_x2
xsubckt_4487_mx3_x2 1 0 9779 3775 3896 1469 3832 3834 mx3_x2
xsubckt_4485_mx3_x2 1 0 9781 3775 3896 1471 3838 3840 mx3_x2
xsubckt_4009_mx2_x2 0 3974 1 706 3975 3977 mx2_x2
xsubckt_3727_o2_x2 0 4251 1 4252 7216 o2_x2
xsubckt_3210_mx3_x2 1 0 4759 703 706 4764 4760 4762 mx3_x2
xsubckt_3080_nand2_x0 1 0 4886 4887 4894 nand2_x0
xsubckt_2907_nand2_x0 1 0 5056 7152 7274 nand2_x0
xsubckt_2464_nand3_x0 1 0 5491 5492 5505 703 nand3_x0
xsubckt_724_nand2_x0 1 0 7079 7081 7135 nand2_x0
xsubckt_634_nand2_x0 1 0 7158 7202 40 nand2_x0
xsubckt_620_nand4_x0 1 0 7171 7175 1738 40 7790 nand4_x0
xsubckt_1404_nand3_x0 1 0 6436 6437 6438 6439 nand3_x0
xsubckt_1599_ao22_x2 0 6242 1 6253 6251 6244 ao22_x2
xsubckt_9400_sff1_x4 1 1872 0 10088 705 sff1_x4
xsubckt_9039_sff1_x4 1 1872 0 9387 183 sff1_x4
xsubckt_8500_sff1_x4 1 1872 0 9893 999 sff1_x4
xsubckt_8059_mx3_x2 1 0 8796 7808 3897 777 3863 3864 mx3_x2
xsubckt_8057_mx3_x2 1 0 8798 7808 3897 779 3871 3872 mx3_x2
xsubckt_7911_mx3_x2 1 0 8934 7818 3896 943 3797 3798 mx3_x2
xsubckt_6774_nand2_x0 1 0 8520 8521 7631 nand2_x0
xsubckt_6684_nand2_x0 1 0 1964 1965 7628 nand2_x0
xsubckt_6272_ao22_x2 0 2367 1 2372 2370 2368 ao22_x2
xsubckt_5909_ao22_x2 0 2722 1 7620 2726 2723 ao22_x2
xsubckt_4922_nand2_x0 1 0 3543 3544 7168 nand2_x0
xsubckt_4041_ao22_x2 0 3943 1 7218 3944 7215 ao22_x2
xsubckt_3954_mx3_x2 1 0 4028 707 705 4029 787 915 mx3_x2
xsubckt_3823_mx2_x2 0 4157 1 705 1685 1557 mx2_x2
xsubckt_3787_o2_x2 0 4192 1 4193 4195 o2_x2
xsubckt_3697_nand2_x0 1 0 4280 7152 7259 nand2_x0
xsubckt_3519_nand2_x0 1 0 4456 7217 1146 nand2_x0
xsubckt_3430_mx2_x2 0 4543 1 705 1469 1309 mx2_x2
xsubckt_3229_ao22_x2 0 4740 1 7216 4741 5586 ao22_x2
xsubckt_3076_nand3_x0 1 0 4890 4891 5056 7104 nand3_x0
xsubckt_1234_oa22_x2 0 6597 1 394 7044 6880 oa22_x2
xsubckt_1757_oa22_x2 0 6087 1 6089 6090 6132 oa22_x2
xsubckt_1845_nand2_x0 1 0 6008 6237 6312 nand2_x0
xsubckt_9831_sff1_x4 1 1872 0 8645 1256 sff1_x4
xsubckt_9474_sff1_x4 1 1872 0 8992 1165 sff1_x4
xsubckt_8574_sff1_x4 1 1872 0 9819 1029 sff1_x4
xsubckt_7372_nand4_x0 1 0 8044 8067 8120 7679 644 nand4_x0
xsubckt_6717_ao22_x2 0 8576 1 8577 8578 8579 ao22_x2
xsubckt_6430_oa22_x2 0 2213 1 40 1741 191 oa22_x2
xsubckt_6069_oa22_x2 0 2566 1 40 1741 175 oa22_x2
xsubckt_5589_nor3_x0 1 0 9471 2979 2980 7702 nor3_x0
xsubckt_3829_nor2_x0 1 0 4151 4152 703 nor2_x0
xsubckt_3827_mx2_x2 0 4153 1 7219 4154 4155 mx2_x2
xsubckt_3825_mx2_x2 0 4155 1 705 1013 821 mx2_x2
xsubckt_3436_mx2_x2 0 4537 1 703 4538 4541 mx2_x2
xsubckt_3434_mx2_x2 0 4539 1 705 1373 861 mx2_x2
xsubckt_3432_mx2_x2 0 4541 1 707 4542 4543 mx2_x2
xsubckt_3174_mx3_x2 1 0 4794 707 705 4795 1314 1474 mx3_x2
xsubckt_3043_mx2_x2 0 4923 1 706 1092 996 mx2_x2
xsubckt_3041_mx2_x2 0 4925 1 706 1220 1156 mx2_x2
xsubckt_2637_nand2_x0 1 0 5321 7153 7292 nand2_x0
xsubckt_2547_nand2_x0 1 0 5409 5410 5424 nand2_x0
xsubckt_719_a3_x2 1 10103 0 7085 7124 7130 a3_x2
xsubckt_1755_nand2_x0 1 0 6089 6091 7788 nand2_x0
xsubckt_2016_nand3_x0 1 0 5852 5863 6386 6406 nand3_x0
xsubckt_2042_oa22_x2 0 5828 1 7234 209 7788 oa22_x2
xsubckt_9382_sff1_x4 1 1872 0 9079 369 sff1_x4
xsubckt_8931_sff1_x4 1 1872 0 9462 1827 sff1_x4
xsubckt_7875_mx3_x2 1 0 8968 7820 3896 1170 3802 3804 mx3_x2
xsubckt_7873_mx3_x2 1 0 8970 7820 3896 1172 3808 3810 mx3_x2
xsubckt_7871_mx3_x2 1 0 8972 7820 3896 1174 3814 3816 mx3_x2
xsubckt_7742_mx2_x2 0 9125 1 7827 3890 1052 mx2_x2
xsubckt_7740_mx2_x2 0 9127 1 7827 3894 1064 mx2_x2
xsubckt_7525_ao22_x2 0 7972 1 5796 5797 414 ao22_x2
xsubckt_7008_mx2_x2 0 8291 1 7631 8292 8293 mx2_x2
xsubckt_7006_mx2_x2 0 8293 1 710 754 1618 mx2_x2
xsubckt_5444_nand2_x0 1 0 3084 1870 1871 nand2_x0
xsubckt_5169_oa22_x2 0 3337 1 3339 3340 7690 oa22_x2
xsubckt_5081_oa22_x2 0 3418 1 3540 3537 3534 oa22_x2
xsubckt_4917_ao22_x2 0 3547 1 1747 3549 40 ao22_x2
xsubckt_3785_mx2_x2 0 4194 1 707 886 854 mx2_x2
xsubckt_3783_mx2_x2 0 4196 1 707 1718 1366 mx2_x2
xsubckt_3781_mx2_x2 0 4198 1 703 4199 4204 mx2_x2
xsubckt_3235_nand4_x0 1 0 4734 5604 532 7689 70 nand4_x0
xsubckt_2800_nand2_x0 1 0 5161 7153 7285 nand2_x0
xsubckt_241_inv_x0 1 0 746 7550 inv_x0
xsubckt_9827_sff1_x4 1 1872 0 8649 1651 sff1_x4
xsubckt_9304_sff1_x4 1 1872 0 9157 1340 sff1_x4
xsubckt_8482_sff1_x4 1 1872 0 9911 1537 sff1_x4
xsubckt_7877_mx3_x2 1 0 8966 7820 3896 1167 3797 3798 mx3_x2
xsubckt_7746_mx2_x2 0 9121 1 7827 3874 1036 mx2_x2
xsubckt_7744_mx2_x2 0 9123 1 7827 3882 1038 mx2_x2
xsubckt_7602_nor2_x0 1 0 7913 7914 7915 nor2_x0
xsubckt_7076_ao22_x2 0 8225 1 7366 710 712 ao22_x2
xsubckt_6606_mx3_x2 1 0 2040 7628 7613 2041 2047 2049 mx3_x2
xsubckt_6604_mx3_x2 1 0 2042 712 710 2043 795 923 mx3_x2
xsubckt_5961_oa22_x2 0 2671 1 2672 2685 7620 oa22_x2
xsubckt_5526_oa22_x2 0 3024 1 1856 3031 1855 oa22_x2
xsubckt_5003_oa22_x2 0 9553 1 7168 3483 3485 oa22_x2
xsubckt_4104_a3_x2 1 3885 0 65 54 51 a3_x2
xsubckt_3502_nand2_x0 1 0 4473 216 688 nand2_x0
xsubckt_2990_mx3_x2 1 0 4975 7215 706 4976 4987 4993 mx3_x2
xsubckt_638_inv_x0 1 0 7157 301 inv_x0
xsubckt_243_inv_x0 1 0 1674 7548 inv_x0
xsubckt_245_inv_x0 1 0 1610 7546 inv_x0
xsubckt_247_inv_x0 1 0 1546 7544 inv_x0
xsubckt_2123_mx2_x2 0 437 1 7043 191 445 mx2_x2
xsubckt_2125_mx2_x2 0 435 1 7043 189 423 mx2_x2
xsubckt_9378_sff1_x4 1 1872 0 9083 373 sff1_x4
xsubckt_9290_sff1_x4 1 1872 0 9171 698 sff1_x4
xsubckt_8927_sff1_x4 1 1872 0 9466 1831 sff1_x4
xsubckt_8404_sff1_x4 1 1872 0 9989 903 sff1_x4
xsubckt_6820_mx2_x2 0 8475 1 710 1014 822 mx2_x2
xsubckt_6702_nor2_x0 1 0 1946 1947 7134 nor2_x0
xsubckt_6431_mx2_x2 0 2212 1 710 1151 991 mx2_x2
xsubckt_5728_a4_x2 0 2863 1 2864 2918 5595 5608 a4_x2
xsubckt_5502_a3_x2 1 3042 0 3047 1862 1863 a3_x2
xsubckt_5331_nor3_x0 1 0 3188 3189 3197 3201 nor3_x0
xsubckt_5101_a2_x2 0 3400 1 3528 662 a2_x2
xsubckt_962_o3_x2 0 6856 1 378 308 307 o3_x2
xsubckt_249_inv_x0 1 0 1705 7542 inv_x0
xsubckt_1217_nand2_x0 1 0 6613 1822 589 nand2_x0
xsubckt_1930_oa22_x2 0 1925 1 6111 5935 5931 oa22_x2
xsubckt_2127_mx2_x2 0 432 1 7043 187 419 mx2_x2
xsubckt_2129_mx2_x2 0 430 1 7043 185 417 mx2_x2
xsubckt_9735_sff1_x4 1 1872 0 8741 1736 sff1_x4
xsubckt_9212_sff1_x4 1 1872 0 9246 647 sff1_x4
xsubckt_8835_sff1_x4 1 1872 0 9558 69 sff1_x4
xsubckt_8478_sff1_x4 1 1872 0 9915 1541 sff1_x4
xsubckt_8390_sff1_x4 1 1872 0 9995 1556 sff1_x4
xsubckt_6780_mx2_x2 0 8514 1 710 1719 887 mx2_x2
xsubckt_6610_nor2_x0 1 0 2036 2037 7134 nor2_x0
xsubckt_6437_mx2_x2 0 2206 1 710 927 799 mx2_x2
xsubckt_6433_mx2_x2 0 2210 1 710 1439 1279 mx2_x2
xsubckt_5876_nor2_x0 1 0 2751 2752 2754 nor2_x0
xsubckt_5788_a4_x2 0 2835 1 2837 2839 2842 2845 a4_x2
xsubckt_5381_nxr2_x1 3141 1 0 3466 665 nxr2_x1
xsubckt_4899_ao22_x2 0 3560 1 1753 3562 40 ao22_x2
xsubckt_4839_a4_x2 0 3606 1 1777 1776 1770 1769 a4_x2
xsubckt_4653_a3_x2 1 3752 0 3754 3763 1773 a3_x2
xsubckt_3496_nand3_x0 1 0 4478 4479 4641 7104 nand3_x0
xsubckt_2668_ao22_x2 0 5291 1 1229 7217 707 ao22_x2
xsubckt_2580_ao22_x2 0 5377 1 5378 5392 5586 ao22_x2
xsubckt_1127_nand2_x0 1 0 6698 587 1764 nand2_x0
xsubckt_1037_nand2_x0 1 0 6784 587 1768 nand2_x0
xsubckt_910_xr2_x1 6906 0 1 673 48 xr2_x1
xsubckt_1245_ao22_x2 0 6587 1 6605 6600 6602 ao22_x2
xsubckt_2097_nand2_x0 1 0 5782 423 308 nand2_x0
xsubckt_2440_nand2_x0 1 0 5515 5516 5520 nand2_x0
xsubckt_9286_sff1_x4 1 1872 0 9175 694 sff1_x4
xsubckt_9208_sff1_x4 1 1872 0 9250 651 sff1_x4
xsubckt_8312_sff1_x4 1 1872 0 10073 226 sff1_x4
xsubckt_7253_a2_x2 0 8130 1 8137 371 a2_x2
xsubckt_7098_a2_x2 0 8203 1 1263 710 a2_x2
xsubckt_6964_ao22_x2 0 8334 1 7625 1587 8335 ao22_x2
xsubckt_6785_a3_x2 1 8509 0 8510 8524 7620 a3_x2
xsubckt_6439_mx2_x2 0 2204 1 712 2205 2206 mx2_x2
xsubckt_6391_mx2_x2 0 2251 1 712 1216 1184 mx2_x2
xsubckt_6364_a2_x2 0 2277 1 2278 708 a2_x2
xsubckt_6344_a2_x2 0 2297 1 2298 7613 a2_x2
xsubckt_5954_nand2_x0 1 0 2678 2679 711 nand2_x0
xsubckt_5904_mx2_x2 0 2727 1 710 1133 973 mx2_x2
xsubckt_5865_oa22_x2 0 2762 1 711 2763 7620 oa22_x2
xsubckt_5630_a2_x2 0 9460 1 2949 2950 a2_x2
xsubckt_5582_a3_x2 1 9473 0 2984 2985 40 a3_x2
xsubckt_4292_a2_x2 0 3789 1 3790 3900 a2_x2
xsubckt_2967_nand2_x0 1 0 4998 5000 5047 nand2_x0
xsubckt_1200_nand2_x0 1 0 6629 1823 589 nand2_x0
xsubckt_1505_a2_x2 0 6336 1 6337 6342 a2_x2
xsubckt_2414_a2_x2 0 5540 1 702 230 a2_x2
xsubckt_9643_sff1_x4 1 1872 0 8833 814 sff1_x4
xsubckt_9120_sff1_x4 1 1872 0 9338 1134 sff1_x4
xsubckt_8743_sff1_x4 1 1872 0 9650 1275 sff1_x4
xsubckt_8386_sff1_x4 1 1872 0 9999 1560 sff1_x4
xsubckt_8308_sff1_x4 1 1872 0 10077 200 sff1_x4
xsubckt_6678_a2_x2 0 1970 1 7437 710 a2_x2
xsubckt_5906_mx2_x2 0 2725 1 710 1421 1261 mx2_x2
xsubckt_5629_ao22_x2 0 2949 1 2954 1824 40 ao22_x2
xsubckt_5541_ao22_x2 0 3013 1 3018 1851 40 ao22_x2
xsubckt_5342_oa22_x2 0 3178 1 7680 3472 7167 oa22_x2
xsubckt_4781_a2_x2 0 3650 1 1785 1783 a2_x2
xsubckt_3759_nand2_x0 1 0 4219 4220 4227 nand2_x0
xsubckt_2734_oa22_x2 0 5226 1 5227 705 707 oa22_x2
xsubckt_1907_nand2_x0 1 0 5952 6350 6355 nand2_x0
xsubckt_2410_ao22_x2 0 5544 1 5545 5547 706 ao22_x2
xsubckt_9639_sff1_x4 1 1872 0 8837 840 sff1_x4
xsubckt_9194_sff1_x4 1 1872 0 9264 659 sff1_x4
xsubckt_9116_sff1_x4 1 1872 0 9342 1160 sff1_x4
xsubckt_6312_o2_x2 0 2328 1 738 710 o2_x2
xsubckt_5862_mx2_x2 0 2765 1 710 1703 1575 mx2_x2
xsubckt_5338_oa22_x2 0 3181 1 7680 3475 7167 oa22_x2
xsubckt_2963_a2_x2 0 5002 1 227 699 a2_x2
xsubckt_1064_o2_x2 0 6758 1 6759 6760 o2_x2
xsubckt_1834_oa22_x2 0 1934 1 6111 6022 6018 oa22_x2
xsubckt_2080_nand2_x0 1 0 5795 230 229 nand2_x0
xsubckt_9551_sff1_x4 1 1872 0 8922 1221 sff1_x4
xsubckt_8739_sff1_x4 1 1872 0 9654 1280 sff1_x4
xsubckt_8651_sff1_x4 1 1872 0 9742 1079 sff1_x4
xsubckt_5416_nand2_x0 1 0 3108 3109 600 nand2_x0
xsubckt_4942_mx2_x2 0 3528 1 5753 3875 112 mx2_x2
xsubckt_4339_mx3_x2 1 0 9916 3786 3897 1542 3859 3860 mx3_x2
xsubckt_4337_mx3_x2 1 0 9918 3786 3897 1514 3867 3868 mx3_x2
xsubckt_4206_mx2_x2 0 3807 1 518 87 1883 mx2_x2
xsubckt_4202_mx2_x2 0 3810 1 518 88 1884 mx2_x2
xsubckt_2642_oa22_x2 0 5316 1 5595 5608 204 oa22_x2
xsubckt_2519_nand2_x0 1 0 5437 5438 7216 nand2_x0
xsubckt_737_ao22_x2 0 7067 1 7684 7106 7068 ao22_x2
xsubckt_1194_nand3_x0 1 0 6635 6638 6641 6660 nand3_x0
xsubckt_1307_oa22_x2 0 6528 1 6551 6546 6549 oa22_x2
xsubckt_1318_o2_x2 0 6517 1 6518 6519 o2_x2
xsubckt_1533_o2_x2 0 6308 1 175 199 o2_x2
xsubckt_2406_ao22_x2 0 5548 1 1672 705 707 ao22_x2
xsubckt_9547_sff1_x4 1 1872 0 8926 1195 sff1_x4
xsubckt_9024_sff1_x4 1 1872 0 9402 198 sff1_x4
xsubckt_8250_mx3_x2 1 0 8583 7798 3896 1616 3799 3801 mx3_x2
xsubckt_8121_mx2_x2 0 8706 1 7803 3886 1681 mx2_x2
xsubckt_5445_ao22_x2 0 3083 1 1871 1870 40 ao22_x2
xsubckt_4946_mx2_x2 0 3525 1 5753 3871 111 mx2_x2
xsubckt_4798_nand3_x0 1 0 3637 3642 1780 1779 nand3_x0
xsubckt_4162_mx2_x2 0 3840 1 518 99 1895 mx2_x2
xsubckt_3892_nor2_x0 1 0 4089 4090 703 nor2_x0
xsubckt_3450_oa22_x2 0 4524 1 5595 5608 217 oa22_x2
xsubckt_2860_nand2_x0 1 0 5103 5104 5151 nand2_x0
xsubckt_1226_nor2_x0 1 0 6605 687 62 nor2_x0
xsubckt_2115_oa22_x2 0 5767 1 7685 308 7244 oa22_x2
xsubckt_2339_nand2_x0 1 0 5614 5615 709 nand2_x0
xsubckt_2392_ao22_x2 0 5562 1 5563 5575 703 ao22_x2
xsubckt_9098_sff1_x4 1 1872 0 1930 1898 sff1_x4
xsubckt_8647_sff1_x4 1 1872 0 9746 1083 sff1_x4
xsubckt_8123_mx2_x2 0 8704 1 7803 3878 1677 mx2_x2
xsubckt_7088_nand2_x0 1 0 8213 8214 8217 nand2_x0
xsubckt_6945_nor2_x0 1 0 9385 8353 8399 nor2_x0
xsubckt_5603_oa22_x2 0 2968 1 1833 2975 1832 oa22_x2
xsubckt_5522_nor2_x0 1 0 3027 3031 1856 nor2_x0
xsubckt_4166_mx2_x2 0 3837 1 518 98 1894 mx2_x2
xsubckt_4025_xr2_x1 3959 0 1 206 678 xr2_x1
xsubckt_3562_nand2_x0 1 0 4413 4414 707 nand2_x0
xsubckt_3415_mx3_x2 1 0 4558 707 705 4559 1533 1661 mx3_x2
xsubckt_803_oa22_x2 0 7008 1 7050 7053 7295 oa22_x2
xsubckt_1_inv_x0 1 0 481 7790 inv_x0
xsubckt_3_inv_x0 1 0 574 7788 inv_x0
xsubckt_1215_oa22_x2 0 6615 1 395 7044 6880 oa22_x2
xsubckt_2062_nxr2_x1 5810 1 0 5811 6426 nxr2_x1
xsubckt_9890_sff1_x4 1 1872 0 8586 1620 sff1_x4
xsubckt_9455_sff1_x4 1 1872 0 9011 1406 sff1_x4
xsubckt_7725_mx3_x2 1 0 9140 7830 3896 1341 3832 3834 mx3_x2
xsubckt_7723_mx3_x2 1 0 9142 7830 3896 1343 3838 3840 mx3_x2
xsubckt_7721_mx3_x2 1 0 9144 7830 3896 1345 3844 3846 mx3_x2
xsubckt_7337_nand3_x0 1 0 8069 8070 8076 8140 nand3_x0
xsubckt_7251_nand2_x0 1 0 8131 8138 601 nand2_x0
xsubckt_6411_oa22_x2 0 2231 1 2232 2247 7620 oa22_x2
xsubckt_4199_nor4_x0 1 0 3812 3821 7743 7744 7745 nor4_x0
xsubckt_3382_nand2_x0 1 0 4590 705 7489 nand2_x0
xsubckt_705_a2_x2 0 7096 1 536 1740 a2_x2
xsubckt_657_a3_x2 1 7138 0 7139 7140 7142 a3_x2
xsubckt_5_inv_x0 1 0 524 7786 inv_x0
xsubckt_7_inv_x0 1 0 483 7784 inv_x0
xsubckt_9_inv_x0 1 0 484 7782 inv_x0
xsubckt_1187_nand2_x0 1 0 6642 689 64 nand2_x0
xsubckt_1607_nxr2_x1 6234 1 0 197 227 nxr2_x1
xsubckt_2069_nand2_x0 1 0 5803 6112 6428 nand2_x0
xsubckt_9812_sff1_x4 1 1872 0 8664 1667 sff1_x4
xsubckt_8990_sff1_x4 1 1872 0 9435 511 sff1_x4
xsubckt_8912_sff1_x4 1 1872 0 9481 1847 sff1_x4
xsubckt_8555_sff1_x4 1 1872 0 9838 1495 sff1_x4
xsubckt_8089_mx2_x2 0 8768 1 7805 3878 749 mx2_x2
xsubckt_8087_mx2_x2 0 8770 1 7805 3886 753 mx2_x2
xsubckt_8085_mx2_x2 0 8772 1 7805 3892 775 mx2_x2
xsubckt_7729_mx3_x2 1 0 9136 7830 3896 1336 3820 3822 mx3_x2
xsubckt_7727_mx3_x2 1 0 9138 7830 3896 1338 3826 3828 mx3_x2
xsubckt_7584_ao22_x2 0 7927 1 607 594 361 ao22_x2
xsubckt_3591_mx2_x2 0 4385 1 7217 7440 7442 mx2_x2
xsubckt_2711_mx2_x2 0 5249 1 705 1708 876 mx2_x2
xsubckt_2586_nand3_x0 1 0 5371 5372 5373 5374 nand3_x0
xsubckt_1123_oa22_x2 0 6702 1 401 7044 6880 oa22_x2
xsubckt_711_oa22_x2 0 7090 1 7091 7111 7123 oa22_x2
xsubckt_656_nor4_x0 1 0 7139 595 596 598 593 nor4_x0
xsubckt_440_inv_x0 1 0 81 7351 inv_x0
xsubckt_9886_sff1_x4 1 1872 0 8590 1624 sff1_x4
xsubckt_9808_sff1_x4 1 1872 0 8668 1641 sff1_x4
xsubckt_9363_sff1_x4 1 1872 0 9098 1042 sff1_x4
xsubckt_8986_sff1_x4 1 1872 0 9439 485 sff1_x4
xsubckt_7293_oa22_x2 0 9296 1 8127 8109 8103 oa22_x2
xsubckt_7067_nand3_x0 1 0 8233 8234 8241 7613 nand3_x0
xsubckt_6896_nand2_x0 1 0 8400 8401 8403 nand2_x0
xsubckt_6718_nand2_x0 1 0 8575 8576 7620 nand2_x0
xsubckt_3988_mx2_x2 0 3995 1 705 1362 850 mx2_x2
xsubckt_3986_mx2_x2 0 3997 1 705 1010 818 mx2_x2
xsubckt_3597_mx2_x2 0 4379 1 705 1401 1241 mx2_x2
xsubckt_3595_mx2_x2 0 4381 1 705 1433 1273 mx2_x2
xsubckt_3553_ao22_x2 0 4422 1 4423 4426 7215 ao22_x2
xsubckt_2849_nand2_x0 1 0 5113 7152 7275 nand2_x0
xsubckt_2715_mx2_x2 0 5245 1 705 1484 1324 mx2_x2
xsubckt_2713_mx2_x2 0 5247 1 706 5248 5251 mx2_x2
xsubckt_742_nand4_x0 1 0 7062 7063 7065 7073 7075 nand4_x0
xsubckt_604_nor3_x0 1 0 7187 595 596 597 nor3_x0
xsubckt_442_inv_x0 1 0 80 7349 inv_x0
xsubckt_444_inv_x0 1 0 79 7347 inv_x0
xsubckt_446_inv_x0 1 0 78 7345 inv_x0
xsubckt_1350_nand2_x0 1 0 6487 587 1750 nand2_x0
xsubckt_2142_nand2_x0 1 0 5756 7044 178 nand2_x0
xsubckt_2322_mx2_x2 0 5631 1 710 1006 814 mx2_x2
xsubckt_9720_sff1_x4 1 1872 0 8756 767 sff1_x4
xsubckt_9359_sff1_x4 1 1872 0 9102 1046 sff1_x4
xsubckt_8908_sff1_x4 1 1872 0 9485 1852 sff1_x4
xsubckt_8820_sff1_x4 1 1872 0 9573 76 sff1_x4
xsubckt_8463_sff1_x4 1 1872 0 9930 723 sff1_x4
xsubckt_7949_mx2_x2 0 8900 1 7813 3892 935 mx2_x2
xsubckt_6592_ao22_x2 0 2054 1 2055 2057 7613 ao22_x2
xsubckt_6416_mx3_x2 1 0 2226 712 710 2227 864 1376 mx3_x2
xsubckt_5493_oa22_x2 0 3048 1 1866 3055 1865 oa22_x2
xsubckt_5058_oa22_x2 0 3439 1 7102 3440 3444 oa22_x2
xsubckt_4717_a4_x2 0 3699 1 3714 3717 1801 1800 a4_x2
xsubckt_2671_mx2_x2 0 5288 1 7217 7570 7572 mx2_x2
xsubckt_685_o3_x2 0 300 1 603 581 582 o3_x2
xsubckt_448_inv_x0 1 0 77 7343 inv_x0
xsubckt_1482_a4_x2 0 6359 1 6360 6365 6371 6376 a4_x2
xsubckt_1753_ao22_x2 0 6091 1 6094 6283 6284 ao22_x2
xsubckt_1877_nand2_x0 1 0 5979 6203 574 nand2_x0
xsubckt_1967_nand2_x0 1 0 5897 6116 6377 nand2_x0
xsubckt_2282_mx2_x2 0 5670 1 712 1681 1649 mx2_x2
xsubckt_2328_mx2_x2 0 5625 1 710 1710 878 mx2_x2
xsubckt_9794_sff1_x4 1 1872 0 8682 1684 sff1_x4
xsubckt_9716_sff1_x4 1 1872 0 8760 771 sff1_x4
xsubckt_9271_sff1_x4 1 1872 0 9190 677 sff1_x4
xsubckt_8894_sff1_x4 1 1872 0 9499 1867 sff1_x4
xsubckt_8459_sff1_x4 1 1872 0 9934 727 sff1_x4
xsubckt_8371_sff1_x4 1 1872 0 10014 1546 sff1_x4
xsubckt_7289_oa22_x2 0 9298 1 8109 8105 8106 oa22_x2
xsubckt_7131_a2_x2 0 9379 1 8173 8174 a2_x2
xsubckt_6632_mx2_x2 0 2015 1 7625 7448 7450 mx2_x2
xsubckt_6378_mx3_x2 1 0 2263 708 7631 2264 2266 2267 mx3_x2
xsubckt_5938_oa22_x2 0 2694 1 40 1741 418 oa22_x2
xsubckt_5480_a3_x2 1 3058 0 3063 1868 1869 a3_x2
xsubckt_5415_oa22_x2 0 3109 1 3115 3113 3111 oa22_x2
xsubckt_4774_nand2_x0 1 0 3655 3657 1786 nand2_x0
xsubckt_3707_oa22_x2 0 4271 1 5595 5608 213 oa22_x2
xsubckt_2807_oa22_x2 0 5154 1 5155 5201 5593 oa22_x2
xsubckt_2730_nor2_x0 1 0 5230 5231 703 nor2_x0
xsubckt_2669_nand2_x0 1 0 5290 5291 5292 nand2_x0
xsubckt_1027_oa22_x2 0 6794 1 6836 6818 6795 oa22_x2
xsubckt_1609_nand2_x0 1 0 6232 6234 6310 nand2_x0
xsubckt_2284_mx2_x2 0 5668 1 712 1617 1585 mx2_x2
xsubckt_2286_mx2_x2 0 5666 1 710 5667 5668 mx2_x2
xsubckt_9267_sff1_x4 1 1872 0 9194 522 sff1_x4
xsubckt_8816_sff1_x4 1 1872 0 9577 1750 sff1_x4
xsubckt_7640_a2_x2 0 9172 1 7882 7886 a2_x2
xsubckt_7322_ao22_x2 0 8082 1 645 7680 573 ao22_x2
xsubckt_6985_mx2_x2 0 8313 1 709 8314 8330 mx2_x2
xsubckt_6981_mx2_x2 0 8317 1 710 1459 1299 mx2_x2
xsubckt_6611_nand2_x0 1 0 2035 2036 2038 nand2_x0
xsubckt_6590_mx2_x2 0 2056 1 710 763 1627 mx2_x2
xsubckt_6588_ao22_x2 0 2058 1 731 710 712 ao22_x2
xsubckt_6358_nand2_x0 1 0 2283 2284 2286 nand2_x0
xsubckt_6262_a2_x2 0 2377 1 7505 710 a2_x2
xsubckt_6065_ao22_x2 0 2569 1 534 532 672 ao22_x2
xsubckt_5579_a3_x2 1 2986 0 2991 1839 1840 a3_x2
xsubckt_4865_a3_x2 1 3586 0 3591 1763 1761 a3_x2
xsubckt_4714_ao22_x2 0 3702 1 1800 3704 40 ao22_x2
xsubckt_4684_nand2_x0 1 0 3728 3731 1804 nand2_x0
xsubckt_3710_a2_x2 0 4268 1 213 685 a2_x2
xsubckt_3181_nand3_x0 1 0 4787 4788 4951 5699 nand3_x0
xsubckt_3170_oa22_x2 0 4798 1 1442 7217 4799 oa22_x2
xsubckt_3066_a2_x2 0 4900 1 4901 7219 a2_x2
xsubckt_2742_nand2_x0 1 0 5218 5219 704 nand2_x0
xsubckt_2489_nand2_x0 1 0 5467 707 1308 nand2_x0
xsubckt_615_oa22_x2 0 7176 1 7191 7181 7177 oa22_x2
xsubckt_1228_a2_x2 0 6603 1 687 62 a2_x2
xsubckt_1519_nand2_x0 1 0 6322 7242 226 nand2_x0
xsubckt_1629_a3_x2 1 6212 0 6217 6233 6242 a3_x2
xsubckt_1749_ao22_x2 0 6094 1 6140 6278 6279 ao22_x2
xsubckt_1950_nand2_x0 1 0 5912 6112 6369 nand2_x0
xsubckt_2203_nor2_x0 1 0 5748 664 649 nor2_x0
xsubckt_9624_sff1_x4 1 1872 0 8849 859 sff1_x4
xsubckt_9101_sff1_x4 1 1872 0 1927 1895 sff1_x4
xsubckt_8367_sff1_x4 1 1872 0 10018 1550 sff1_x4
xsubckt_7667_nand3_x0 1 0 7859 7861 7679 644 nand3_x0
xsubckt_7396_ao22_x2 0 8024 1 645 7680 588 ao22_x2
xsubckt_7313_nand2_x0 1 0 8088 8138 571 nand2_x0
xsubckt_6771_a2_x2 0 8523 1 7420 710 a2_x2
xsubckt_6598_mx2_x2 0 2048 1 710 1723 891 mx2_x2
xsubckt_6596_mx2_x2 0 2050 1 710 1499 1339 mx2_x2
xsubckt_6521_nand2_x0 1 0 2124 2125 712 nand2_x0
xsubckt_4843_nor3_x0 1 0 9593 3603 3604 7702 nor3_x0
xsubckt_4718_a2_x2 0 9622 1 3700 3702 a2_x2
xsubckt_4070_o3_x2 0 3914 1 4020 4077 5698 o3_x2
xsubckt_3615_oa22_x2 0 4361 1 7219 4362 703 oa22_x2
xsubckt_1717_a2_x2 0 6124 1 6125 7221 a2_x2
xsubckt_2031_nand3_x0 1 0 5838 5885 6384 6396 nand3_x0
xsubckt_9698_sff1_x4 1 1872 0 8778 788 sff1_x4
xsubckt_9175_sff1_x4 1 1872 0 9283 574 sff1_x4
xsubckt_8724_sff1_x4 1 1872 0 9669 1287 sff1_x4
xsubckt_8015_nand2_x0 1 0 7809 3793 3796 nand2_x0
xsubckt_6631_o3_x2 0 2016 1 2017 2018 7620 o3_x2
xsubckt_6341_nand2_x0 1 0 2300 2301 2302 nand2_x0
xsubckt_5635_nand3_x0 1 0 2945 2951 1822 1823 nand3_x0
xsubckt_5596_ao22_x2 0 2973 1 2978 1834 40 ao22_x2
xsubckt_5118_nand2_x0 1 0 3384 3385 3387 nand2_x0
xsubckt_4925_mx3_x2 1 0 3541 5754 518 7751 7698 7699 mx3_x2
xsubckt_4532_mx3_x2 1 0 9736 3773 3896 1072 3799 3801 mx3_x2
xsubckt_4530_mx3_x2 1 0 9738 3773 3896 1075 3805 3807 mx3_x2
xsubckt_4141_mx3_x2 1 0 10043 3899 3897 1605 3856 3857 mx3_x2
xsubckt_3354_nand2_x0 1 0 4618 4619 4620 nand2_x0
xsubckt_2881_a2_x2 0 5082 1 5083 706 a2_x2
xsubckt_2686_a2_x2 0 5273 1 5279 703 a2_x2
xsubckt_11_inv_x0 1 0 1742 7780 inv_x0
xsubckt_13_inv_x0 1 0 118 7778 inv_x0
xsubckt_1502_nand2_x0 1 0 6339 190 220 nand2_x0
xsubckt_1815_oa22_x2 0 6035 1 176 200 574 oa22_x2
xsubckt_9532_sff1_x4 1 1872 0 8934 943 sff1_x4
xsubckt_8798_sff1_x4 1 1872 0 9595 1770 sff1_x4
xsubckt_8104_mx3_x2 1 0 8753 7806 3896 763 3829 3831 mx3_x2
xsubckt_8102_mx3_x2 1 0 8755 7806 3896 766 3835 3837 mx3_x2
xsubckt_8100_mx3_x2 1 0 8757 7806 3896 768 3841 3843 mx3_x2
xsubckt_6544_o2_x2 0 2101 1 1661 710 o2_x2
xsubckt_5953_ao22_x2 0 2679 1 2680 2682 2683 ao22_x2
xsubckt_5361_o2_x2 0 3159 1 3160 3178 o2_x2
xsubckt_5266_nxr2_x1 3248 1 0 3490 666 nxr2_x1
xsubckt_4929_mx3_x2 1 0 3538 5754 518 7752 7354 7355 mx3_x2
xsubckt_4490_mx3_x2 1 0 9776 3775 3896 1465 3823 3825 mx3_x2
xsubckt_4405_mx2_x2 0 9857 1 3778 3878 1485 mx2_x2
xsubckt_4403_mx2_x2 0 9859 1 3778 3886 1489 mx2_x2
xsubckt_4401_mx2_x2 0 9861 1 3778 3892 1511 mx2_x2
xsubckt_4145_mx3_x2 1 0 10042 3899 3896 1604 3853 3855 mx3_x2
xsubckt_4056_nand2_x0 1 0 3928 3929 7219 nand2_x0
xsubckt_4010_mx2_x2 0 3973 1 703 3974 3979 mx2_x2
xsubckt_3000_oa22_x2 0 4965 1 4966 705 7218 oa22_x2
xsubckt_2472_nand2_x0 1 0 5483 5484 7179 nand2_x0
xsubckt_1159_nand2_x0 1 0 6668 1825 589 nand2_x0
xsubckt_597_oa22_x2 0 7194 1 7197 7201 7206 oa22_x2
xsubckt_15_inv_x0 1 0 120 7776 inv_x0
xsubckt_17_inv_x0 1 0 122 7774 inv_x0
xsubckt_19_inv_x0 1 0 124 7772 inv_x0
xsubckt_1578_xr2_x1 6263 0 1 420 204 xr2_x1
xsubckt_2100_oa22_x2 0 5779 1 7685 308 7241 oa22_x2
xsubckt_9528_sff1_x4 1 1872 0 8938 948 sff1_x4
xsubckt_9083_sff1_x4 1 1872 0 9343 525 sff1_x4
xsubckt_8632_sff1_x4 1 1872 0 9761 1069 sff1_x4
xsubckt_8108_mx3_x2 1 0 8749 7806 3896 759 3817 3819 mx3_x2
xsubckt_8106_mx3_x2 1 0 8751 7806 3896 761 3823 3825 mx3_x2
xsubckt_8060_mx3_x2 1 0 8795 7808 3897 806 3859 3860 mx3_x2
xsubckt_6584_o2_x2 0 2062 1 1659 710 o2_x2
xsubckt_6562_oa22_x2 0 2083 1 7631 2084 7628 oa22_x2
xsubckt_6071_nand2_x0 1 0 2564 2565 712 nand2_x0
xsubckt_5830_o2_x2 0 2796 1 2797 7631 o2_x2
xsubckt_4496_mx3_x2 1 0 9770 3775 3896 1459 3805 3807 mx3_x2
xsubckt_4494_mx3_x2 1 0 9772 3775 3896 1461 3811 3813 mx3_x2
xsubckt_4492_mx3_x2 1 0 9774 3775 3896 1463 3817 3819 mx3_x2
xsubckt_4409_mx2_x2 0 9853 1 3778 3862 1481 mx2_x2
xsubckt_4407_mx2_x2 0 9855 1 3778 3870 1483 mx2_x2
xsubckt_4149_mx3_x2 1 0 10041 3899 3896 1603 3850 3852 mx3_x2
xsubckt_1285_nor2_x0 1 0 6549 684 59 nor2_x0
xsubckt_1725_o2_x2 0 6116 1 571 572 o2_x2
xsubckt_9440_sff1_x4 1 1872 0 9026 1393 sff1_x4
xsubckt_9005_sff1_x4 1 1872 0 9420 495 sff1_x4
xsubckt_8628_sff1_x4 1 1872 0 9765 1095 sff1_x4
xsubckt_8066_mx3_x2 1 0 8789 7808 3896 800 3841 3843 mx3_x2
xsubckt_8064_mx3_x2 1 0 8791 7808 3896 802 3847 3849 mx3_x2
xsubckt_8062_mx3_x2 1 0 8793 7808 3896 804 3853 3855 mx3_x2
xsubckt_7470_nand3_x0 1 0 7990 7991 7993 7995 nand3_x0
xsubckt_7370_oa22_x2 0 9276 1 8076 8046 8047 oa22_x2
xsubckt_7134_ao22_x2 0 8170 1 7102 7780 7791 ao22_x2
xsubckt_6410_nand3_x0 1 0 2232 2233 2240 7613 nand3_x0
xsubckt_5718_nand2_x0 1 0 2873 2874 7215 nand2_x0
xsubckt_4498_mx3_x2 1 0 9768 3775 3896 1456 3799 3801 mx3_x2
xsubckt_4369_mx2_x2 0 9890 1 3781 3882 974 mx2_x2
xsubckt_4367_mx2_x2 0 9892 1 3781 3890 988 mx2_x2
xsubckt_4365_mx2_x2 0 9894 1 3781 3894 1000 mx2_x2
xsubckt_4200_nxr2_x1 3811 1 0 3815 7745 nxr2_x1
xsubckt_3830_mx2_x2 0 4150 1 704 1429 1141 mx2_x2
xsubckt_1142_nand2_x0 1 0 6684 587 1763 nand2_x0
xsubckt_730_a3_x2 1 7073 0 7074 7124 7130 a3_x2
xsubckt_710_a3_x2 1 7091 0 7092 7095 7098 a3_x2
xsubckt_1849_nand2_x0 1 0 6004 6006 6318 nand2_x0
xsubckt_1939_nand2_x0 1 0 5922 6112 6364 nand2_x0
xsubckt_2024_nand2_x0 1 0 5844 6116 6391 nand2_x0
xsubckt_9436_sff1_x4 1 1872 0 9030 44 sff1_x4
xsubckt_9079_sff1_x4 1 1872 0 9347 1298 sff1_x4
xsubckt_8540_sff1_x4 1 1872 0 9853 1481 sff1_x4
xsubckt_8068_mx3_x2 1 0 8787 7808 3896 798 3835 3837 mx3_x2
xsubckt_7926_mx3_x2 1 0 8921 7816 3896 1220 3853 3855 mx3_x2
xsubckt_7924_mx3_x2 1 0 8923 7816 3897 1222 3859 3860 mx3_x2
xsubckt_7922_mx3_x2 1 0 8925 7816 3897 1194 3867 3868 mx3_x2
xsubckt_6941_nand2_x0 1 0 8356 8357 2729 nand2_x0
xsubckt_5658_oa22_x2 0 2928 1 1817 2935 1816 oa22_x2
xsubckt_5570_oa22_x2 0 2992 1 1843 2999 1842 oa22_x2
xsubckt_5185_nand3_x0 1 0 3323 40 135 7780 nand3_x0
xsubckt_3869_nor2_x0 1 0 4112 210 682 nor2_x0
xsubckt_3832_mx2_x2 0 4148 1 704 1269 981 mx2_x2
xsubckt_2988_o2_x2 0 4977 1 4978 4980 o2_x2
xsubckt_623_a2_x2 0 7168 1 40 1742 a2_x2
xsubckt_2301_mx3_x2 1 0 5652 712 710 5653 1230 1390 mx3_x2
xsubckt_9871_sff1_x4 1 1872 0 8605 1610 sff1_x4
xsubckt_8971_sff1_x4 1 1872 0 154 91 sff1_x4
xsubckt_8536_sff1_x4 1 1872 0 9857 1485 sff1_x4
xsubckt_7928_mx3_x2 1 0 8919 7816 3896 1218 3847 3849 mx3_x2
xsubckt_7406_mx2_x2 0 9068 1 7199 389 357 mx2_x2
xsubckt_7404_mx2_x2 0 9069 1 7199 390 358 mx2_x2
xsubckt_7402_mx2_x2 0 9070 1 7199 391 359 mx2_x2
xsubckt_7376_nand4_x0 1 0 8041 8063 8070 8078 8140 nand4_x0
xsubckt_7148_mx3_x2 1 0 9368 8167 3897 1290 3867 3868 mx3_x2
xsubckt_7042_ao22_x2 0 8258 1 711 8261 7613 ao22_x2
xsubckt_7015_mx2_x2 0 8284 1 710 1458 1298 mx2_x2
xsubckt_7013_mx2_x2 0 8286 1 710 1202 1074 mx2_x2
xsubckt_7011_mx2_x2 0 8288 1 712 8289 8290 mx2_x2
xsubckt_5577_nor2_x0 1 0 2987 2991 1840 nor2_x0
xsubckt_4077_ao22_x2 0 10055 1 3908 3955 3962 ao22_x2
xsubckt_3790_mx2_x2 0 4189 1 707 822 790 mx2_x2
xsubckt_3058_mx2_x2 0 4908 1 705 1732 900 mx2_x2
xsubckt_3056_mx2_x2 0 4910 1 707 4911 4912 mx2_x2
xsubckt_3054_mx2_x2 0 4912 1 705 932 804 mx2_x2
xsubckt_2962_oa22_x2 0 5003 1 5595 5608 227 oa22_x2
xsubckt_663_a2_x2 0 7132 1 40 482 a2_x2
xsubckt_1669_nand2_x0 1 0 6172 7228 215 nand2_x0
xsubckt_2004_oa22_x2 0 5863 1 6398 5883 5864 oa22_x2
xsubckt_9867_sff1_x4 1 1872 0 8609 1614 sff1_x4
xsubckt_9344_sff1_x4 1 1872 0 9117 1062 sff1_x4
xsubckt_7888_mx3_x2 1 0 8957 7818 3897 938 3867 3868 mx3_x2
xsubckt_7408_mx2_x2 0 9067 1 7199 388 356 mx2_x2
xsubckt_7017_mx2_x2 0 8282 1 712 8283 8284 mx2_x2
xsubckt_5701_nand2_x0 1 0 2890 2891 2897 nand2_x0
xsubckt_5230_a4_x2 0 3281 1 3321 3498 3501 3504 a4_x2
xsubckt_5078_nxr2_x1 3421 1 0 3422 3425 nxr2_x1
xsubckt_5043_oa22_x2 0 9543 1 7168 3453 3455 oa22_x2
xsubckt_3796_mx2_x2 0 4183 1 705 1430 1270 mx2_x2
xsubckt_3794_mx2_x2 0 4185 1 705 1494 1334 mx2_x2
xsubckt_3506_nand2_x0 1 0 4469 4472 4522 nand2_x0
xsubckt_611_nor2_x0 1 0 7180 1738 1737 nor2_x0
xsubckt_250_inv_x0 1 0 1353 7541 inv_x0
xsubckt_252_inv_x0 1 0 841 7539 inv_x0
xsubckt_254_inv_x0 1 0 1577 7537 inv_x0
xsubckt_1832_nand2_x0 1 0 6019 6112 6314 nand2_x0
xsubckt_1918_nand3_x0 1 0 5941 5942 5943 5944 nand3_x0
xsubckt_9701_sff1_x4 1 1872 0 8775 784 sff1_x4
xsubckt_8967_sff1_x4 1 1872 0 158 95 sff1_x4
xsubckt_8444_sff1_x4 1 1872 0 9949 713 sff1_x4
xsubckt_7473_ao22_x2 0 7987 1 7989 7992 2858 ao22_x2
xsubckt_7362_a4_x2 0 8051 1 8067 373 7659 371 a4_x2
xsubckt_6313_nand2_x0 1 0 2327 2328 712 nand2_x0
xsubckt_5785_nand3_x0 1 0 2838 5606 40 7780 nand3_x0
xsubckt_5123_a3_x2 1 3380 0 40 110 7780 a3_x2
xsubckt_3594_nand2_x0 1 0 4382 4383 4388 nand2_x0
xsubckt_2888_nand3_x0 1 0 5075 5076 5077 7216 nand3_x0
xsubckt_2527_mx2_x2 0 5429 1 705 924 796 mx2_x2
xsubckt_2525_mx2_x2 0 5431 1 705 1020 828 mx2_x2
xsubckt_1090_oa22_x2 0 165 1 6748 6747 6734 oa22_x2
xsubckt_1047_nxr2_x1 6775 1 0 697 72 nxr2_x1
xsubckt_997_a2_x2 0 6822 1 228 1739 a2_x2
xsubckt_256_inv_x0 1 0 1225 7535 inv_x0
xsubckt_258_inv_x0 1 0 1161 7533 inv_x0
xsubckt_1213_a3_x2 1 6617 0 6621 6635 6642 a3_x2
xsubckt_1742_nand2_x0 1 0 6100 6114 6278 nand2_x0
xsubckt_9775_sff1_x4 1 1872 0 8701 1674 sff1_x4
xsubckt_9252_sff1_x4 1 1872 0 9209 326 sff1_x4
xsubckt_8801_sff1_x4 1 1872 0 9592 1767 sff1_x4
xsubckt_7638_nor2_x0 1 0 7883 7884 7885 nor2_x0
xsubckt_7295_a3_x2 1 8101 0 531 7679 644 a3_x2
xsubckt_6835_mx2_x2 0 8460 1 710 1718 886 mx2_x2
xsubckt_6833_mx2_x2 0 8462 1 710 1494 1334 mx2_x2
xsubckt_6120_a2_x2 0 9403 1 2516 2566 a2_x2
xsubckt_6051_mx2_x2 0 2583 1 710 1450 1290 mx2_x2
xsubckt_5612_a3_x2 1 2962 0 2967 1829 1830 a3_x2
xsubckt_5431_nand2_x0 1 0 9513 3095 3105 nand2_x0
xsubckt_5088_nand2_x0 1 0 3412 3532 7653 nand2_x0
xsubckt_5039_oa22_x2 0 9544 1 7168 3456 3458 oa22_x2
xsubckt_4725_nand3_x0 1 0 3693 3699 1799 1798 nand3_x0
xsubckt_1106_a2_x2 0 6718 1 7143 1864 a2_x2
xsubckt_968_nand2_x0 1 0 6850 588 1744 nand2_x0
xsubckt_2343_oa22_x2 0 5610 1 664 529 1739 oa22_x2
xsubckt_8875_sff1_x4 1 1872 0 9518 122 sff1_x4
xsubckt_8352_sff1_x4 1 1872 0 10033 1594 sff1_x4
xsubckt_6839_mx2_x2 0 8456 1 710 1206 1078 mx2_x2
xsubckt_6837_mx2_x2 0 8458 1 7631 8459 8460 mx2_x2
xsubckt_6448_mx2_x2 0 2195 1 712 2196 2197 mx2_x2
xsubckt_6446_mx2_x2 0 2197 1 710 735 1599 mx2_x2
xsubckt_6180_a2_x2 0 2457 1 7521 710 a2_x2
xsubckt_6057_mx2_x2 0 2577 1 710 1418 1258 mx2_x2
xsubckt_6053_mx2_x2 0 2581 1 712 2582 2583 mx2_x2
xsubckt_5911_mx2_x2 0 2720 1 710 1005 813 mx2_x2
xsubckt_5393_nor2_x0 1 0 3130 3131 3132 nor2_x0
xsubckt_5251_nand2_x0 1 0 3262 3493 7663 nand2_x0
xsubckt_4931_oa22_x2 0 9571 1 7168 3537 3539 oa22_x2
xsubckt_4773_ao22_x2 0 3656 1 1786 3657 40 ao22_x2
xsubckt_4743_a3_x2 1 9616 0 3680 3682 40 a3_x2
xsubckt_3753_nand3_x0 1 0 4225 4226 4407 7104 nand3_x0
xsubckt_3639_a3_x2 1 4337 0 4338 5595 5608 a3_x2
xsubckt_3218_a2_x2 0 4751 1 4752 7217 a2_x2
xsubckt_2524_a2_x2 0 5432 1 5433 704 a2_x2
xsubckt_925_o2_x2 0 6891 1 6892 6898 o2_x2
xsubckt_691_o2_x2 0 7110 1 43 42 o2_x2
xsubckt_1186_a2_x2 0 6643 1 689 64 a2_x2
xsubckt_1615_a2_x2 0 6226 1 6227 6228 a2_x2
xsubckt_2309_a2_x2 0 5644 1 5645 7625 a2_x2
xsubckt_2354_nand2_x0 1 0 5600 5601 40 nand2_x0
xsubckt_9683_sff1_x4 1 1872 0 8793 804 sff1_x4
xsubckt_9605_sff1_x4 1 1872 0 8868 871 sff1_x4
xsubckt_9248_sff1_x4 1 1872 0 9213 331 sff1_x4
xsubckt_9160_sff1_x4 1 1872 0 9298 593 sff1_x4
xsubckt_8348_sff1_x4 1 1872 0 10037 1599 sff1_x4
xsubckt_7637_a2_x2 0 7884 1 668 600 a2_x2
xsubckt_6926_ao22_x2 0 8371 1 8376 8374 8372 ao22_x2
xsubckt_6748_a2_x2 0 8545 1 8546 8557 a2_x2
xsubckt_6708_a2_x2 0 1941 1 7423 710 a2_x2
xsubckt_6059_mx2_x2 0 2575 1 710 1002 810 mx2_x2
xsubckt_5565_a2_x2 0 2996 1 2999 1843 a2_x2
xsubckt_4831_a2_x2 0 9596 1 3612 3614 a2_x2
xsubckt_3438_ao22_x2 0 4535 1 706 4536 5586 ao22_x2
xsubckt_2564_a2_x2 0 5393 1 5394 7215 a2_x2
xsubckt_1420_xr2_x1 6421 0 1 178 206 xr2_x1
xsubckt_1800_oa22_x2 0 6048 1 6299 6116 6112 oa22_x2
xsubckt_2251_oa22_x2 0 5700 1 7675 5702 5701 oa22_x2
xsubckt_9679_sff1_x4 1 1872 0 8797 778 sff1_x4
xsubckt_8783_sff1_x4 1 1872 0 9610 1787 sff1_x4
xsubckt_8705_sff1_x4 1 1872 0 9688 1122 sff1_x4
xsubckt_7535_oa22_x2 0 7965 1 7970 7093 7211 oa22_x2
xsubckt_7116_o2_x2 0 8185 1 8186 7134 o2_x2
xsubckt_5919_mx2_x2 0 2712 1 710 749 1613 mx2_x2
xsubckt_5839_a2_x2 0 2787 1 2788 5743 a2_x2
xsubckt_5071_nand2_x0 1 0 9540 3428 3438 nand2_x0
xsubckt_4927_oa22_x2 0 9572 1 7168 3540 3542 oa22_x2
xsubckt_4891_a2_x2 0 9582 1 3566 3568 a2_x2
xsubckt_4871_a2_x2 0 9586 1 3582 3583 a2_x2
xsubckt_4340_mx3_x2 1 0 9915 3786 3897 1541 3856 3857 mx3_x2
xsubckt_3767_a2_x2 0 4212 1 212 684 a2_x2
xsubckt_3346_ao22_x2 0 4626 1 7487 705 707 ao22_x2
xsubckt_1024_nand2_x0 1 0 6797 698 73 nand2_x0
xsubckt_589_nor2_x0 1 0 7202 344 343 nor2_x0
xsubckt_1380_xr2_x1 6459 0 1 678 53 xr2_x1
xsubckt_1999_nand2_x0 1 0 5867 6114 6405 nand2_x0
xsubckt_9591_sff1_x4 1 1872 0 8882 925 sff1_x4
xsubckt_9513_sff1_x4 1 1872 0 8953 964 sff1_x4
xsubckt_9156_sff1_x4 1 1872 0 9302 604 sff1_x4
xsubckt_8779_sff1_x4 1 1872 0 9614 1791 sff1_x4
xsubckt_8691_sff1_x4 1 1872 0 9702 1128 sff1_x4
xsubckt_7597_o3_x2 0 7917 1 7918 7952 7955 o3_x2
xsubckt_7577_o3_x2 0 7932 1 7933 7952 7955 o3_x2
xsubckt_7557_o3_x2 0 7947 1 7948 7952 7955 o3_x2
xsubckt_7285_ao22_x2 0 8107 1 645 7680 596 ao22_x2
xsubckt_7086_oa22_x2 0 8215 1 7625 1135 8216 oa22_x2
xsubckt_6823_nand2_x0 1 0 8472 1398 7625 nand2_x0
xsubckt_6202_nand3_x0 1 0 2435 2436 2445 709 nand3_x0
xsubckt_6112_oa22_x2 0 2523 1 7631 2524 7628 oa22_x2
xsubckt_5688_nand2_x0 1 0 2903 707 7356 nand2_x0
xsubckt_5584_nand4_x0 1 0 2982 2991 1838 1839 1840 nand4_x0
xsubckt_4792_nand4_x0 1 0 3641 3646 3657 1786 1781 nand4_x0
xsubckt_4606_mx2_x2 0 9670 1 3764 3894 1288 mx2_x2
xsubckt_4346_mx3_x2 1 0 9909 3786 3896 1535 3838 3840 mx3_x2
xsubckt_4344_mx3_x2 1 0 9911 3786 3896 1537 3844 3846 mx3_x2
xsubckt_4342_mx3_x2 1 0 9913 3786 3896 1539 3850 3852 mx3_x2
xsubckt_4175_o2_x2 0 3830 1 3833 7739 o2_x2
xsubckt_3504_oa22_x2 0 4471 1 4523 4520 4522 oa22_x2
xsubckt_2969_ao22_x2 0 4996 1 5045 4998 4997 ao22_x2
xsubckt_947_nand3_x0 1 0 6870 6871 6872 6873 nand3_x0
xsubckt_861_nand2_x0 1 0 6952 588 1773 nand2_x0
xsubckt_9587_sff1_x4 1 1872 0 8886 929 sff1_x4
xsubckt_9064_sff1_x4 1 1872 0 9362 1314 sff1_x4
xsubckt_8613_sff1_x4 1 1872 0 9780 1470 sff1_x4
xsubckt_7642_ao22_x2 0 7880 1 607 594 373 ao22_x2
xsubckt_5934_ao22_x2 0 2697 1 2698 2713 2729 ao22_x2
xsubckt_5411_ao22_x2 0 3113 1 3145 3116 3114 ao22_x2
xsubckt_5286_oa22_x2 0 3230 1 7680 3484 7167 oa22_x2
xsubckt_4608_mx2_x2 0 9668 1 3764 3890 1276 mx2_x2
xsubckt_4348_mx3_x2 1 0 9907 3786 3896 1533 3832 3834 mx3_x2
xsubckt_3656_nand2_x0 1 0 4321 4322 707 nand2_x0
xsubckt_3125_nand3_x0 1 0 4842 4843 5008 7104 nand3_x0
xsubckt_2864_nand2_x0 1 0 5099 5100 5102 nand2_x0
xsubckt_2592_o2_x2 0 5365 1 5366 7180 o2_x2
xsubckt_1739_nxr2_x1 6103 1 0 6104 6277 nxr2_x1
xsubckt_9509_sff1_x4 1 1872 0 8957 938 sff1_x4
xsubckt_9421_sff1_x4 1 1872 0 9045 1374 sff1_x4
xsubckt_8687_sff1_x4 1 1872 0 9706 1427 sff1_x4
xsubckt_7435_nand2_x0 1 0 9244 8015 8017 nand2_x0
xsubckt_5678_nxr2_x1 2913 1 0 2914 2915 nxr2_x1
xsubckt_5208_oa22_x2 0 3301 1 7102 3306 3302 oa22_x2
xsubckt_5120_oa22_x2 0 3382 1 3383 3384 3388 oa22_x2
xsubckt_3935_oa22_x2 0 4047 1 1203 7217 4048 oa22_x2
xsubckt_3854_nor2_x0 1 0 4126 4127 706 nor2_x0
xsubckt_3566_nand2_x0 1 0 4409 7153 7266 nand2_x0
xsubckt_2877_ao22_x2 0 5086 1 7535 7217 707 ao22_x2
xsubckt_2506_nand2_x0 1 0 5450 5451 5460 nand2_x0
xsubckt_677_nand3_x0 1 0 7119 7125 7130 40 nand3_x0
xsubckt_1690_oa22_x2 0 6151 1 6153 6154 6419 oa22_x2
xsubckt_1892_nand2_x0 1 0 5965 6114 6351 nand2_x0
xsubckt_9495_sff1_x4 1 1872 0 8971 1173 sff1_x4
xsubckt_8609_sff1_x4 1 1872 0 9784 1474 sff1_x4
xsubckt_8521_sff1_x4 1 1872 0 9872 985 sff1_x4
xsubckt_8090_mx2_x2 0 8767 1 7805 3874 748 mx2_x2
xsubckt_7732_mx3_x2 1 0 9133 7830 3896 1333 3811 3813 mx3_x2
xsubckt_7730_mx3_x2 1 0 9135 7830 3896 1335 3817 3819 mx3_x2
xsubckt_7255_nand2_x0 1 0 8128 8138 603 nand2_x0
xsubckt_7115_ao22_x2 0 8186 1 534 532 677 ao22_x2
xsubckt_5194_oa22_x2 0 3314 1 3316 3317 7690 oa22_x2
xsubckt_3251_mx2_x2 0 4719 1 705 1024 832 mx2_x2
xsubckt_2063_oa22_x2 0 5809 1 5819 6152 6421 oa22_x2
xsubckt_9852_sff1_x4 1 1872 0 8624 1242 sff1_x4
xsubckt_9417_sff1_x4 1 1872 0 9049 1378 sff1_x4
xsubckt_8595_sff1_x4 1 1872 0 9798 1480 sff1_x4
xsubckt_8092_mx2_x2 0 8765 1 7805 3866 746 mx2_x2
xsubckt_7736_mx3_x2 1 0 9129 7830 3896 1328 3799 3801 mx3_x2
xsubckt_7734_mx3_x2 1 0 9131 7830 3896 1331 3805 3807 mx3_x2
xsubckt_7682_nand3_x0 1 0 7847 7849 7679 644 nand3_x0
xsubckt_7075_nand2_x0 1 0 8226 1519 710 nand2_x0
xsubckt_3991_mx2_x2 0 3992 1 706 3993 3996 mx2_x2
xsubckt_3779_mx3_x2 1 0 4200 707 705 4201 1526 1654 mx3_x2
xsubckt_3777_mx3_x2 1 0 4202 707 705 4203 1590 726 mx3_x2
xsubckt_3503_xr2_x1 4472 0 1 216 688 xr2_x1
xsubckt_3255_mx2_x2 0 4715 1 705 1152 992 mx2_x2
xsubckt_3253_mx2_x2 0 4717 1 7219 4718 4719 mx2_x2
xsubckt_104_inv_x0 1 0 229 7687 inv_x0
xsubckt_102_inv_x0 1 0 594 7689 inv_x0
xsubckt_100_inv_x0 1 0 599 7691 inv_x0
xsubckt_1686_oa22_x2 0 6155 1 6157 6161 6407 oa22_x2
xsubckt_2420_oa22_x2 0 5534 1 5586 5541 5535 oa22_x2
xsubckt_8952_sff1_x4 1 1872 0 144 81 sff1_x4
xsubckt_8517_sff1_x4 1 1872 0 9876 990 sff1_x4
xsubckt_7954_mx2_x2 0 8895 1 7813 3874 908 mx2_x2
xsubckt_7952_mx2_x2 0 8897 1 7813 3882 910 mx2_x2
xsubckt_7950_mx2_x2 0 8899 1 7813 3890 924 mx2_x2
xsubckt_7216_mx2_x2 0 9095 1 7199 409 377 mx2_x2
xsubckt_6421_mx3_x2 1 0 2221 712 710 2222 800 928 mx3_x2
xsubckt_4651_oa22_x2 0 3753 1 3754 3763 7702 oa22_x2
xsubckt_3593_ao22_x2 0 4383 1 4384 4386 7218 ao22_x2
xsubckt_2494_oa22_x2 0 5462 1 5463 5464 704 oa22_x2
xsubckt_108_inv_x0 1 0 44 7683 inv_x0
xsubckt_106_inv_x0 1 0 307 7685 inv_x0
xsubckt_451_inv_x0 1 0 1902 7340 inv_x0
xsubckt_453_inv_x0 1 0 1901 7338 inv_x0
xsubckt_1555_nxr2_x1 6286 1 0 419 203 nxr2_x1
xsubckt_1961_nand3_x0 1 0 5902 5903 5904 6111 nand3_x0
xsubckt_9848_sff1_x4 1 1872 0 8628 1247 sff1_x4
xsubckt_9760_sff1_x4 1 1872 0 8716 1718 sff1_x4
xsubckt_9325_sff1_x4 1 1872 0 9136 1336 sff1_x4
xsubckt_8948_sff1_x4 1 1872 0 170 107 sff1_x4
xsubckt_8425_sff1_x4 1 1872 0 9968 889 sff1_x4
xsubckt_7697_nor2_x0 1 0 7835 7836 7837 nor2_x0
xsubckt_7176_mx2_x2 0 8161 1 8163 8162 524 mx2_x2
xsubckt_6423_mx3_x2 1 0 2219 7628 7613 2220 2226 2228 mx3_x2
xsubckt_6197_ao22_x2 0 2440 1 7625 965 2441 ao22_x2
xsubckt_5462_a4_x2 0 3071 1 3079 1815 1826 1837 a4_x2
xsubckt_5315_a3_x2 1 3203 0 3217 3224 3225 a3_x2
xsubckt_3999_mx2_x2 0 3984 1 706 1170 1106 mx2_x2
xsubckt_3515_ao22_x2 0 4460 1 4461 4464 707 ao22_x2
xsubckt_2680_mx2_x2 0 5279 1 706 5280 5282 mx2_x2
xsubckt_455_inv_x0 1 0 1900 7336 inv_x0
xsubckt_457_inv_x0 1 0 1899 7334 inv_x0
xsubckt_459_inv_x0 1 0 1898 7332 inv_x0
xsubckt_2056_nand2_x0 1 0 5815 6116 6421 nand2_x0
xsubckt_2333_mx2_x2 0 5620 1 712 1678 1646 mx2_x2
xsubckt_2335_mx2_x2 0 5618 1 712 1614 1582 mx2_x2
xsubckt_2337_mx2_x2 0 5616 1 710 5617 5618 mx2_x2
xsubckt_9756_sff1_x4 1 1872 0 8720 1722 sff1_x4
xsubckt_9399_sff1_x4 1 1872 0 10089 706 sff1_x4
xsubckt_8860_sff1_x4 1 1872 0 9533 138 sff1_x4
xsubckt_8499_sff1_x4 1 1872 0 9894 1000 sff1_x4
xsubckt_8150_a2_x2 0 7802 1 3787 3790 a2_x2
xsubckt_6643_mx2_x2 0 2004 1 710 1018 826 mx2_x2
xsubckt_6252_mx2_x2 0 2387 1 712 1155 1123 mx2_x2
xsubckt_5470_nand3_x0 1 0 3065 3071 1809 1810 nand3_x0
xsubckt_4827_a4_x2 0 3615 1 1775 1774 1772 1771 a4_x2
xsubckt_4641_a3_x2 1 9637 0 3761 3762 40 a3_x2
xsubckt_4398_a4_x2 0 3779 1 3780 3901 3903 3906 a4_x2
xsubckt_4071_nand2_x0 1 0 3913 7153 7257 nand2_x0
xsubckt_4043_nor2_x0 1 0 3941 3942 3949 nor2_x0
xsubckt_3011_nand2_x0 1 0 4954 4955 4974 nand2_x0
xsubckt_2926_nand2_x0 1 0 5038 5039 5041 nand2_x0
xsubckt_1084_nand2_x0 1 0 6739 587 1766 nand2_x0
xsubckt_1044_a2_x2 0 6778 1 697 72 a2_x2
xsubckt_1028_nxr2_x1 6793 1 0 6794 6796 nxr2_x1
xsubckt_743_nand2_x0 1 0 10101 7062 7066 nand2_x0
xsubckt_1270_ao22_x2 0 6563 1 6586 6583 6584 ao22_x2
xsubckt_1804_mx2_x2 0 6045 1 574 6046 6250 mx2_x2
xsubckt_2207_a2_x2 0 5744 1 5746 5748 a2_x2
xsubckt_9233_sff1_x4 1 1872 0 9228 318 sff1_x4
xsubckt_8856_sff1_x4 1 1872 0 9537 112 sff1_x4
xsubckt_8333_sff1_x4 1 1872 0 10052 1596 sff1_x4
xsubckt_7675_nand2_x0 1 0 7853 662 600 nand2_x0
xsubckt_7241_a2_x2 0 8140 1 7679 644 a2_x2
xsubckt_6911_ao22_x2 0 8386 1 7625 1300 8387 ao22_x2
xsubckt_6883_nand2_x0 1 0 8413 8414 711 nand2_x0
xsubckt_6256_mx2_x2 0 2383 1 710 2384 2385 mx2_x2
xsubckt_6254_mx2_x2 0 2385 1 712 1091 1059 mx2_x2
xsubckt_5654_ao22_x2 0 2931 1 2935 1817 40 ao22_x2
xsubckt_5590_a3_x2 1 2978 0 2983 1835 1836 a3_x2
xsubckt_5443_a2_x2 0 9511 1 40 7704 a2_x2
xsubckt_5324_nxr2_x1 3194 1 0 3212 3477 nxr2_x1
xsubckt_4534_a2_x2 0 3771 1 3780 3796 a2_x2
xsubckt_4067_nand3_x0 1 0 3917 3918 3933 704 nand3_x0
xsubckt_3628_nand2_x0 1 0 4348 4349 7215 nand2_x0
xsubckt_3298_oa22_x2 0 4673 1 4728 4724 4674 oa22_x2
xsubckt_1789_ao22_x2 0 6058 1 574 6060 6059 ao22_x2
xsubckt_2299_mx2_x2 0 5654 1 710 1486 1326 mx2_x2
xsubckt_9664_sff1_x4 1 1872 0 8812 822 sff1_x4
xsubckt_9229_sff1_x4 1 1872 0 9232 343 sff1_x4
xsubckt_9141_sff1_x4 1 1872 0 9317 1142 sff1_x4
xsubckt_7317_nand2_x0 1 0 8085 8095 8124 nand2_x0
xsubckt_6998_mx2_x2 0 8301 1 710 1010 818 mx2_x2
xsubckt_5852_mx3_x2 1 0 2775 712 710 2776 7606 7610 mx3_x2
xsubckt_5112_nand3_x0 1 0 3390 3407 3525 3528 nand3_x0
xsubckt_3665_a2_x2 0 4312 1 4313 7217 a2_x2
xsubckt_3625_a2_x2 0 4351 1 4352 4353 a2_x2
xsubckt_3196_a2_x2 0 4773 1 4777 4830 a2_x2
xsubckt_2755_oa22_x2 0 5206 1 5259 5258 5257 oa22_x2
xsubckt_2746_nand2_x0 1 0 5214 7153 7288 nand2_x0
xsubckt_1230_xr2_x1 6601 0 1 687 62 xr2_x1
xsubckt_1378_a2_x2 0 6461 1 678 53 a2_x2
xsubckt_1553_a2_x2 0 6288 1 419 203 a2_x2
xsubckt_1593_a2_x2 0 6248 1 176 200 a2_x2
xsubckt_1764_mx2_x2 0 6081 1 574 6082 6266 mx2_x2
xsubckt_1827_a2_x2 0 6024 1 6025 6308 a2_x2
xsubckt_1864_nand2_x0 1 0 5990 6114 6223 nand2_x0
xsubckt_8764_sff1_x4 1 1872 0 9629 1745 sff1_x4
xsubckt_8329_sff1_x4 1 1872 0 10056 208 sff1_x4
xsubckt_7034_o2_x2 0 8266 1 8267 8269 o2_x2
xsubckt_5858_mx3_x2 1 0 2769 712 710 2770 1607 743 mx3_x2
xsubckt_5720_oa22_x2 0 2871 1 2873 2875 706 oa22_x2
xsubckt_5681_mx2_x2 0 2910 1 707 2911 2912 mx2_x2
xsubckt_3965_nand3_x0 1 0 4017 4018 4176 7104 nand3_x0
xsubckt_3358_nand2_x0 1 0 4614 4615 4618 nand2_x0
xsubckt_2756_a2_x2 0 5205 1 201 673 a2_x2
xsubckt_1153_nand3_x0 1 0 6674 6676 6690 6692 nand3_x0
xsubckt_20_inv_x0 1 0 125 7771 inv_x0
xsubckt_2232_oa22_x2 0 5719 1 5721 5727 711 oa22_x2
xsubckt_9572_sff1_x4 1 1872 0 8901 936 sff1_x4
xsubckt_9137_sff1_x4 1 1872 0 9321 1146 sff1_x4
xsubckt_8111_mx3_x2 1 0 8746 7806 3896 756 3808 3810 mx3_x2
xsubckt_6345_nand2_x0 1 0 2296 2297 2300 nand2_x0
xsubckt_5794_oa22_x2 0 9414 1 7192 7189 2831 oa22_x2
xsubckt_5685_mx2_x2 0 2906 1 707 2907 2908 mx2_x2
xsubckt_5683_mx2_x2 0 2908 1 7217 7362 7366 mx2_x2
xsubckt_4545_mx3_x2 1 0 9725 3771 3897 1417 3863 3864 mx3_x2
xsubckt_4543_mx3_x2 1 0 9727 3771 3897 1419 3871 3872 mx3_x2
xsubckt_4053_o2_x2 0 3931 1 705 1168 o2_x2
xsubckt_3611_nand2_x0 1 0 4365 4366 4368 nand2_x0
xsubckt_22_inv_x0 1 0 127 7769 inv_x0
xsubckt_24_inv_x0 1 0 130 7767 inv_x0
xsubckt_26_inv_x0 1 0 132 7765 inv_x0
xsubckt_1506_nand2_x0 1 0 6335 6337 6342 nand2_x0
xsubckt_1594_nand2_x0 1 0 6247 176 200 nand2_x0
xsubckt_8672_sff1_x4 1 1872 0 9721 1443 sff1_x4
xsubckt_8115_mx3_x2 1 0 8742 7806 3896 751 3797 3798 mx3_x2
xsubckt_8113_mx3_x2 1 0 8744 7806 3896 754 3802 3804 mx3_x2
xsubckt_7300_nand2_x0 1 0 8098 8138 610 nand2_x0
xsubckt_6889_ao22_x2 0 8407 1 8412 8410 8408 ao22_x2
xsubckt_6674_o2_x2 0 1974 1 1657 710 o2_x2
xsubckt_6165_nand2_x0 1 0 2472 2473 7631 nand2_x0
xsubckt_5459_nand3_x0 1 0 3073 3079 1826 1837 nand3_x0
xsubckt_5228_nxr2_x1 3283 1 0 3284 3287 nxr2_x1
xsubckt_4549_mx3_x2 1 0 9721 3771 3896 1443 3850 3852 mx3_x2
xsubckt_4547_mx3_x2 1 0 9723 3771 3897 1445 3856 3857 mx3_x2
xsubckt_4370_mx2_x2 0 9889 1 3781 3878 973 mx2_x2
xsubckt_3673_o2_x2 0 4304 1 4305 4307 o2_x2
xsubckt_3404_nor2_x0 1 0 10067 4569 4633 nor2_x0
xsubckt_28_inv_x0 1 0 134 7763 inv_x0
xsubckt_1326_nand2_x0 1 0 6510 682 57 nand2_x0
xsubckt_2118_nand2_x0 1 0 5765 193 307 nand2_x0
xsubckt_2208_nand2_x0 1 0 5743 5746 5748 nand2_x0
xsubckt_2295_o2_x2 0 5657 1 5658 7103 o2_x2
xsubckt_2386_nand2_x0 1 0 5568 5569 7219 nand2_x0
xsubckt_9568_sff1_x4 1 1872 0 8905 1203 sff1_x4
xsubckt_9480_sff1_x4 1 1872 0 8986 1189 sff1_x4
xsubckt_9045_sff1_x4 1 1872 0 9381 177 sff1_x4
xsubckt_8668_sff1_x4 1 1872 0 9725 1417 sff1_x4
xsubckt_8073_mx3_x2 1 0 8782 7808 3896 792 3820 3822 mx3_x2
xsubckt_8071_mx3_x2 1 0 8784 7808 3896 794 3826 3828 mx3_x2
xsubckt_7100_ao22_x2 0 8201 1 8202 8203 708 ao22_x2
xsubckt_6200_ao22_x2 0 2437 1 2438 2440 708 ao22_x2
xsubckt_5989_ao22_x2 0 2644 1 7555 7625 712 ao22_x2
xsubckt_5267_oa22_x2 0 3247 1 3264 3262 3263 oa22_x2
xsubckt_4223_nand2_x0 1 0 3794 3796 3907 nand2_x0
xsubckt_3101_mx2_x2 0 4866 1 705 1475 1315 mx2_x2
xsubckt_2589_o2_x2 0 5368 1 207 679 o2_x2
xsubckt_1146_nand2_x0 1 0 6680 221 1739 nand2_x0
xsubckt_1236_nand2_x0 1 0 6595 588 1792 nand2_x0
xsubckt_1247_nor2_x0 1 0 6585 686 61 nor2_x0
xsubckt_1843_nand3_x0 1 0 6009 6010 6011 6012 nand3_x0
xsubckt_2028_nand2_x0 1 0 1916 5841 5845 nand2_x0
xsubckt_9402_sff1_x4 1 1872 0 10086 703 sff1_x4
xsubckt_8580_sff1_x4 1 1872 0 9813 1023 sff1_x4
xsubckt_8502_sff1_x4 1 1872 0 9891 977 sff1_x4
xsubckt_8079_mx3_x2 1 0 8776 7808 3896 786 3802 3804 mx3_x2
xsubckt_8077_mx3_x2 1 0 8778 7808 3896 788 3808 3810 mx3_x2
xsubckt_8075_mx3_x2 1 0 8780 7808 3896 790 3814 3816 mx3_x2
xsubckt_7933_mx3_x2 1 0 8914 7816 3896 1213 3832 3834 mx3_x2
xsubckt_7931_mx3_x2 1 0 8916 7816 3896 1215 3838 3840 mx3_x2
xsubckt_3161_nand2_x0 1 0 4807 4808 4809 nand2_x0
xsubckt_824_oa22_x2 0 6988 1 7041 7126 7638 oa22_x2
xsubckt_805_nand2_x0 1 0 7006 7007 7047 nand2_x0
xsubckt_9833_sff1_x4 1 1872 0 8643 1244 sff1_x4
xsubckt_9476_sff1_x4 1 1872 0 8990 1163 sff1_x4
xsubckt_8576_sff1_x4 1 1872 0 9817 1027 sff1_x4
xsubckt_7937_mx3_x2 1 0 8910 7816 3896 1208 3820 3822 mx3_x2
xsubckt_7935_mx3_x2 1 0 8912 7816 3896 1210 3826 3828 mx3_x2
xsubckt_7633_nand4_x0 1 0 7887 7888 7951 7957 8140 nand4_x0
xsubckt_7413_mx2_x2 0 9263 1 5752 9065 670 mx2_x2
xsubckt_7411_mx2_x2 0 9264 1 5752 9066 659 mx2_x2
xsubckt_7155_mx3_x2 1 0 9361 8167 3896 1313 3844 3846 mx3_x2
xsubckt_7153_mx3_x2 1 0 9363 8167 3896 1315 3850 3852 mx3_x2
xsubckt_7151_mx3_x2 1 0 9365 8167 3897 1317 3856 3857 mx3_x2
xsubckt_6765_nand2_x0 1 0 8529 8530 711 nand2_x0
xsubckt_5099_nand3_x0 1 0 3402 40 112 7780 nand3_x0
xsubckt_3847_mx2_x2 0 4133 1 704 4134 4137 mx2_x2
xsubckt_3845_mx2_x2 0 4135 1 705 1365 853 mx2_x2
xsubckt_3500_ao22_x2 0 10065 1 4475 4518 4524 ao22_x2
xsubckt_3065_mx2_x2 0 4901 1 705 1444 1284 mx2_x2
xsubckt_713_a2_x2 0 7088 1 7089 40 a2_x2
xsubckt_301_inv_x0 1 0 830 7490 inv_x0
xsubckt_303_inv_x0 1 0 734 7488 inv_x0
xsubckt_1926_nand2_x0 1 0 5934 6116 6343 nand2_x0
xsubckt_2101_nand2_x0 1 0 443 5779 5782 nand2_x0
xsubckt_9384_sff1_x4 1 1872 0 9077 367 sff1_x4
xsubckt_9310_sff1_x4 1 1872 0 9151 1322 sff1_x4
xsubckt_8933_sff1_x4 1 1872 0 9460 1824 sff1_x4
xsubckt_8410_sff1_x4 1 1872 0 9983 875 sff1_x4
xsubckt_7939_mx3_x2 1 0 8908 7816 3896 1206 3814 3816 mx3_x2
xsubckt_7895_mx3_x2 1 0 8950 7818 3896 961 3844 3846 mx3_x2
xsubckt_7893_mx3_x2 1 0 8952 7818 3896 963 3850 3852 mx3_x2
xsubckt_7891_mx3_x2 1 0 8954 7818 3897 965 3856 3857 mx3_x2
xsubckt_7527_ao22_x2 0 9196 1 7971 7972 7973 ao22_x2
xsubckt_7419_mx2_x2 0 9258 1 5752 9064 665 mx2_x2
xsubckt_7415_mx2_x2 0 9261 1 5752 9082 668 mx2_x2
xsubckt_7159_mx3_x2 1 0 9357 8167 3896 1309 3832 3834 mx3_x2
xsubckt_7157_mx3_x2 1 0 9359 8167 3896 1311 3838 3840 mx3_x2
xsubckt_7133_nor3_x0 1 0 8171 8172 8183 7791 nor3_x0
xsubckt_7028_mx2_x2 0 8272 1 712 976 944 mx2_x2
xsubckt_7026_mx2_x2 0 8274 1 712 1136 1104 mx2_x2
xsubckt_6675_nand2_x0 1 0 1973 1974 712 nand2_x0
xsubckt_4144_nxr2_x1 3853 1 0 3858 7732 nxr2_x1
xsubckt_3574_ao22_x2 0 10064 1 4402 4467 4474 ao22_x2
xsubckt_2600_ao22_x2 0 5358 1 5370 5369 5368 ao22_x2
xsubckt_931_ao22_x2 0 6886 1 6909 6908 6907 ao22_x2
xsubckt_773_a2_x2 0 7036 1 7143 1871 a2_x2
xsubckt_261_inv_x0 1 0 1733 7530 inv_x0
xsubckt_305_inv_x0 1 0 1438 7486 inv_x0
xsubckt_307_inv_x0 1 0 1278 7484 inv_x0
xsubckt_309_inv_x0 1 0 1182 7482 inv_x0
xsubckt_2011_nand2_x0 1 0 5856 6116 6386 nand2_x0
xsubckt_9829_sff1_x4 1 1872 0 8647 1648 sff1_x4
xsubckt_9741_sff1_x4 1 1872 0 8735 1708 sff1_x4
xsubckt_9306_sff1_x4 1 1872 0 9155 1326 sff1_x4
xsubckt_8484_sff1_x4 1 1872 0 9909 1535 sff1_x4
xsubckt_7899_mx3_x2 1 0 8946 7818 3896 957 3832 3834 mx3_x2
xsubckt_7897_mx3_x2 1 0 8948 7818 3896 959 3838 3840 mx3_x2
xsubckt_7671_oa22_x2 0 7856 1 644 7679 673 oa22_x2
xsubckt_7377_nand2_x0 1 0 9274 8041 8042 nand2_x0
xsubckt_6626_mx3_x2 1 0 2021 712 710 2022 1594 730 mx3_x2
xsubckt_6624_mx3_x2 1 0 2023 712 710 2024 1530 1658 mx3_x2
xsubckt_6585_nand2_x0 1 0 2061 2062 712 nand2_x0
xsubckt_6407_nand2_x0 1 0 2235 2236 7631 nand2_x0
xsubckt_5082_nand3_x0 1 0 3417 3418 3419 7690 nand3_x0
xsubckt_2929_mx2_x2 0 5035 1 7219 5036 5037 mx2_x2
xsubckt_2927_mx2_x2 0 5037 1 705 1510 1350 mx2_x2
xsubckt_728_oa22_x2 0 7075 1 7137 7150 7676 oa22_x2
xcmpt_zero_19 1 0 632 zero_x1
xcmpt_zero_18 1 0 633 zero_x1
xcmpt_zero_17 1 0 634 zero_x1
xcmpt_zero_16 1 0 635 zero_x1
xcmpt_zero_15 1 0 636 zero_x1
xcmpt_zero_14 1 0 637 zero_x1
xcmpt_zero_13 1 0 638 zero_x1
xcmpt_zero_12 1 0 639 zero_x1
xcmpt_zero_11 1 0 640 zero_x1
xcmpt_zero_10 1 0 641 zero_x1
xsubckt_263_inv_x0 1 0 901 7528 inv_x0
xsubckt_265_inv_x0 1 0 805 7526 inv_x0
xsubckt_267_inv_x0 1 0 741 7524 inv_x0
xsubckt_1700_ao22_x2 0 6141 1 6144 6431 528 ao22_x2
xsubckt_1746_nand2_x0 1 0 6097 6114 6283 nand2_x0
xsubckt_2278_mx3_x2 1 0 5674 712 710 5675 785 913 mx3_x2
xsubckt_9292_sff1_x4 1 1872 0 9169 700 sff1_x4
xsubckt_8929_sff1_x4 1 1872 0 9464 1829 sff1_x4
xsubckt_8841_sff1_x4 1 1872 0 9552 62 sff1_x4
xsubckt_8406_sff1_x4 1 1872 0 9987 881 sff1_x4
xsubckt_7540_nand2_x0 1 0 9192 7962 7963 nand2_x0
xsubckt_6840_mx2_x2 0 8455 1 710 758 1622 mx2_x2
xsubckt_6451_mx2_x2 0 2192 1 712 2193 2194 mx2_x2
xsubckt_6317_nand2_x0 1 0 2323 2324 7628 nand2_x0
xsubckt_6106_mx2_x2 0 2529 1 7625 7532 7534 mx2_x2
xsubckt_5527_a3_x2 1 9488 0 3024 3025 40 a3_x2
xsubckt_5106_a2_x2 0 3395 1 3407 3528 a2_x2
xsubckt_3494_nand4_x0 1 0 4480 5604 532 7689 64 nand4_x0
xsubckt_2883_mx2_x2 0 5080 1 705 1481 1321 mx2_x2
xsubckt_2478_a4_x2 0 5477 1 5478 5479 5480 5483 a4_x2
xsubckt_693_o3_x2 0 7108 1 41 43 42 o3_x2
xsubckt_269_inv_x0 1 0 1605 7522 inv_x0
xsubckt_1444_nxr2_x1 6397 1 0 184 213 nxr2_x1
xsubckt_1566_nand2_x0 1 0 6275 446 7686 nand2_x0
xsubckt_1932_oa22_x2 0 5929 1 6336 5949 6182 oa22_x2
xsubckt_9737_sff1_x4 1 1872 0 8739 1724 sff1_x4
xsubckt_9214_sff1_x4 1 1872 0 9244 702 sff1_x4
xsubckt_8392_sff1_x4 1 1872 0 9993 1554 sff1_x4
xsubckt_7536_nand3_x0 1 0 7964 7168 656 7791 nand3_x0
xsubckt_4658_a3_x2 1 3748 0 3749 3754 3763 a3_x2
xsubckt_4639_nand3_x0 1 0 3762 644 1807 1742 nand3_x0
xsubckt_4638_a3_x2 1 3763 0 644 1807 1742 a3_x2
xsubckt_4432_a2_x2 0 3777 1 3796 3904 a2_x2
xsubckt_3581_nand2_x0 1 0 4395 215 687 nand2_x0
xsubckt_2889_mx2_x2 0 5074 1 705 1129 969 mx2_x2
xsubckt_2498_mx2_x2 0 5458 1 705 1724 892 mx2_x2
xsubckt_930_xr2_x1 6887 0 1 672 47 xr2_x1
xcmpt_zero_20 1 0 630 zero_x1
xcmpt_zero_21 1 0 629 zero_x1
xcmpt_zero_22 1 0 628 zero_x1
xcmpt_zero_23 1 0 627 zero_x1
xcmpt_zero_24 1 0 626 zero_x1
xcmpt_zero_25 1 0 625 zero_x1
xcmpt_zero_26 1 0 624 zero_x1
xcmpt_zero_27 1 0 623 zero_x1
xcmpt_zero_28 1 0 622 zero_x1
xcmpt_zero_29 1 0 621 zero_x1
xsubckt_1216_a2_x2 0 6614 1 7143 1857 a2_x2
xsubckt_1416_nor2_x0 1 0 6425 178 206 nor2_x0
xsubckt_1431_a2_x2 0 6410 1 179 208 a2_x2
xsubckt_1905_nand3_x0 1 0 5953 5954 5955 5956 nand3_x0
xsubckt_2305_oa22_x2 0 5648 1 7631 5654 711 oa22_x2
xsubckt_2320_a2_x2 0 5633 1 7578 710 a2_x2
xsubckt_9288_sff1_x4 1 1872 0 9173 696 sff1_x4
xsubckt_8837_sff1_x4 1 1872 0 9556 67 sff1_x4
xsubckt_8314_sff1_x4 1 1872 0 10071 224 sff1_x4
xsubckt_7278_a2_x2 0 8112 1 8113 8114 a2_x2
xsubckt_6654_nand3_x0 1 0 1993 1994 2001 7613 nand3_x0
xsubckt_6443_ao22_x2 0 2200 1 7620 2201 7613 ao22_x2
xsubckt_5924_mx2_x2 0 2707 1 712 2708 2709 mx2_x2
xsubckt_5922_mx2_x2 0 2709 1 710 1357 845 mx2_x2
xsubckt_5920_mx2_x2 0 2711 1 710 717 1581 mx2_x2
xsubckt_5655_a2_x2 0 9453 1 2931 2932 a2_x2
xsubckt_4971_oa22_x2 0 9561 1 7168 3507 3509 oa22_x2
xsubckt_4901_a2_x2 0 9579 1 3559 3560 a2_x2
xsubckt_4746_a2_x2 0 9615 1 3678 3679 a2_x2
xsubckt_4678_a3_x2 1 9628 0 3733 3736 40 a3_x2
xsubckt_3817_a2_x2 0 4163 1 211 683 a2_x2
xsubckt_3577_nand3_x0 1 0 4399 4469 4470 4473 nand3_x0
xsubckt_2578_ao22_x2 0 5379 1 5386 703 706 ao22_x2
xsubckt_2521_nand2_x0 1 0 5435 5436 5443 nand2_x0
xsubckt_1386_nand2_x0 1 0 6453 588 1783 nand2_x0
xsubckt_1471_a2_x2 0 6370 1 6371 6376 a2_x2
xsubckt_1697_a3_x2 1 6144 0 6145 6197 6426 a3_x2
xsubckt_1705_a2_x2 0 6136 1 423 207 a2_x2
xsubckt_2178_nand2_x0 1 0 5752 7132 7194 nand2_x0
xsubckt_9645_sff1_x4 1 1872 0 8831 812 sff1_x4
xsubckt_9122_sff1_x4 1 1872 0 9336 1132 sff1_x4
xsubckt_8745_sff1_x4 1 1872 0 9648 1273 sff1_x4
xsubckt_8388_sff1_x4 1 1872 0 9997 1558 sff1_x4
xsubckt_7575_oa22_x2 0 7934 1 644 7679 684 oa22_x2
xsubckt_7468_nor3_x0 1 0 7992 344 343 481 nor3_x0
xsubckt_6878_a2_x2 0 8418 1 7406 710 a2_x2
xsubckt_6800_ao22_x2 0 8494 1 8509 8497 8495 ao22_x2
xsubckt_6043_o2_x2 0 2591 1 714 710 o2_x2
xsubckt_5928_mx2_x2 0 2703 1 710 1453 1293 mx2_x2
xsubckt_5926_mx2_x2 0 2705 1 710 1197 1069 mx2_x2
xsubckt_5880_mx2_x2 0 2747 1 710 1159 999 mx2_x2
xsubckt_5291_nxr2_x1 3225 1 0 3484 665 nxr2_x1
xsubckt_4967_oa22_x2 0 9562 1 7168 3510 3512 oa22_x2
xsubckt_4712_nand3_x0 1 0 3703 3718 3745 1801 nand3_x0
xsubckt_3583_nxr2_x1 4393 1 0 4394 4400 nxr2_x1
xsubckt_3022_o2_x2 0 4944 1 226 698 o2_x2
xsubckt_2490_ao22_x2 0 5466 1 7595 707 705 ao22_x2
xsubckt_1046_xr2_x1 6776 0 1 697 72 xr2_x1
xsubckt_912_nor2_x0 1 0 6904 6905 7791 nor2_x0
xcmpt_zero_30 1 0 619 zero_x1
xcmpt_zero_31 1 0 618 zero_x1
xcmpt_zero_32 1 0 516 zero_x1
xcmpt_zero_33 1 0 515 zero_x1
xcmpt_zero_34 1 0 479 zero_x1
xcmpt_zero_35 1 0 478 zero_x1
xcmpt_zero_36 1 0 295 zero_x1
xcmpt_zero_37 1 0 294 zero_x1
xcmpt_zero_38 1 0 283 zero_x1
xcmpt_zero_39 1 0 272 zero_x1
xsubckt_1204_o2_x2 0 6625 1 6626 6627 o2_x2
xsubckt_2088_nand2_x0 1 0 5789 175 307 nand2_x0
xsubckt_2412_ao22_x2 0 5542 1 5543 5554 7215 ao22_x2
xsubckt_9196_sff1_x4 1 1872 0 9262 669 sff1_x4
xsubckt_9118_sff1_x4 1 1872 0 9340 1148 sff1_x4
xsubckt_6898_a2_x2 0 8399 1 7134 7233 a2_x2
xsubckt_6874_ao22_x2 0 8422 1 7625 1301 8423 ao22_x2
xsubckt_5882_mx2_x2 0 2745 1 7628 2746 2748 mx2_x2
xsubckt_5213_nxr2_x1 3297 1 0 3304 3501 nxr2_x1
xsubckt_5134_o2_x2 0 9535 1 3370 3380 o2_x2
xsubckt_4808_nor2_x0 1 0 3629 3631 7711 nor2_x0
xsubckt_4611_mx2_x2 0 9665 1 3764 3878 1261 mx2_x2
xsubckt_4353_mx3_x2 1 0 9902 3786 3896 1527 3817 3819 mx3_x2
xsubckt_4351_mx3_x2 1 0 9904 3786 3896 1529 3823 3825 mx3_x2
xsubckt_4008_mx3_x2 1 0 3975 707 705 3976 1586 722 mx3_x2
xsubckt_4006_mx3_x2 1 0 3977 707 705 3978 1522 1650 mx3_x2
xsubckt_3544_oa22_x2 0 4431 1 1370 7218 4432 oa22_x2
xsubckt_3021_oa22_x2 0 4945 1 5595 5608 226 oa22_x2
xsubckt_775_nand2_x0 1 0 7034 1845 589 nand2_x0
xsubckt_9553_sff1_x4 1 1872 0 8920 1219 sff1_x4
xsubckt_9030_sff1_x4 1 1872 0 9396 192 sff1_x4
xsubckt_8653_sff1_x4 1 1872 0 9740 1077 sff1_x4
xsubckt_6516_nor2_x0 1 0 2128 2129 7134 nor2_x0
xsubckt_6116_nand3_x0 1 0 2519 2520 2545 2729 nand3_x0
xsubckt_5855_nand2_x0 1 0 2772 2775 7628 nand2_x0
xsubckt_4359_mx3_x2 1 0 9896 3786 3896 1520 3799 3801 mx3_x2
xsubckt_4357_mx3_x2 1 0 9898 3786 3896 1523 3805 3807 mx3_x2
xsubckt_4355_mx3_x2 1 0 9900 3786 3896 1525 3811 3813 mx3_x2
xsubckt_4226_mx2_x2 0 10020 1 3794 3890 1564 mx2_x2
xsubckt_4224_mx2_x2 0 10022 1 3794 3894 1576 mx2_x2
xsubckt_3028_nor2_x0 1 0 4938 4939 7180 nor2_x0
xsubckt_2868_nand2_x0 1 0 5095 5096 7218 nand2_x0
xsubckt_2591_nxr2_x1 5366 1 0 5367 5370 nxr2_x1
xsubckt_975_oa22_x2 0 140 1 6859 6857 6844 oa22_x2
xsubckt_739_ao22_x2 0 7065 1 7136 7149 7675 ao22_x2
xsubckt_671_nand4_x0 1 0 7124 7126 7128 7129 40 nand4_x0
xcmpt_zero_49 1 0 290 zero_x1
xcmpt_zero_48 1 0 291 zero_x1
xcmpt_zero_47 1 0 292 zero_x1
xcmpt_zero_46 1 0 293 zero_x1
xcmpt_zero_45 1 0 264 zero_x1
xcmpt_zero_44 1 0 265 zero_x1
xcmpt_zero_43 1 0 266 zero_x1
xcmpt_zero_42 1 0 267 zero_x1
xcmpt_zero_41 1 0 268 zero_x1
xcmpt_zero_40 1 0 269 zero_x1
xsubckt_1744_oa22_x2 0 1935 1 6111 6103 6099 oa22_x2
xsubckt_1808_nand2_x0 1 0 6041 6116 6246 nand2_x0
xsubckt_1986_nand2_x0 1 0 5879 6116 6398 nand2_x0
xsubckt_9549_sff1_x4 1 1872 0 8924 1193 sff1_x4
xsubckt_9461_sff1_x4 1 1872 0 9005 1399 sff1_x4
xsubckt_9026_sff1_x4 1 1872 0 9400 196 sff1_x4
xsubckt_6810_nand2_x0 1 0 8485 1110 7625 nand2_x0
xsubckt_6782_ao22_x2 0 8512 1 8517 8515 8513 ao22_x2
xsubckt_6347_ao22_x2 0 2294 1 7495 7625 712 ao22_x2
xsubckt_5675_nand2_x0 1 0 2916 2917 7254 nand2_x0
xsubckt_5661_nand4_x0 1 0 2926 2935 1814 1816 1817 nand4_x0
xsubckt_4966_mx2_x2 0 3510 1 5753 3855 136 mx2_x2
xsubckt_4962_mx2_x2 0 3513 1 5753 3856 137 mx2_x2
xsubckt_4883_nand2_x0 1 0 3572 3573 3574 nand2_x0
xsubckt_4705_nand2_x0 1 0 3710 3712 3713 nand2_x0
xsubckt_4575_mx2_x2 0 9698 1 3767 3882 1102 mx2_x2
xsubckt_4573_mx2_x2 0 9700 1 3767 3890 1116 mx2_x2
xsubckt_4571_mx2_x2 0 9702 1 3767 3894 1128 mx2_x2
xsubckt_4228_mx2_x2 0 10018 1 3794 3882 1550 mx2_x2
xsubckt_4182_mx2_x2 0 3825 1 518 93 1889 mx2_x2
xsubckt_3824_mx3_x2 1 0 4156 707 705 4157 1525 1653 mx3_x2
xsubckt_3739_ao22_x2 0 4239 1 7416 7217 707 ao22_x2
xsubckt_595_nand2_x0 1 0 7196 7200 7203 nand2_x0
xsubckt_8649_sff1_x4 1 1872 0 9744 1081 sff1_x4
xsubckt_8561_sff1_x4 1 1872 0 9832 1488 sff1_x4
xsubckt_7678_ao22_x2 0 9165 1 7854 7851 7852 ao22_x2
xsubckt_7590_ao22_x2 0 9181 1 7956 7923 7925 ao22_x2
xsubckt_7391_oa22_x2 0 9273 1 8028 8037 8040 oa22_x2
xsubckt_7259_nand2_x0 1 0 8125 8138 605 nand2_x0
xsubckt_5997_o2_x2 0 2636 1 2637 7631 o2_x2
xsubckt_5117_nxr2_x1 3385 1 0 3526 661 nxr2_x1
xsubckt_4577_mx2_x2 0 9696 1 3767 3874 1100 mx2_x2
xsubckt_4258_nand4_x0 1 0 3791 3793 3901 3903 3906 nand4_x0
xsubckt_4186_mx2_x2 0 3822 1 518 92 1888 mx2_x2
xsubckt_3733_nand2_x0 1 0 4245 4246 4247 nand2_x0
xsubckt_3448_oa22_x2 0 4525 1 7179 4563 4526 oa22_x2
xsubckt_3437_mx3_x2 1 0 4536 704 7215 4537 4544 4546 mx3_x2
xsubckt_3409_nxr2_x1 4564 1 0 219 691 nxr2_x1
xsubckt_3306_mx2_x2 0 4665 1 705 1407 1247 mx2_x2
xsubckt_3304_mx2_x2 0 4667 1 705 1695 1567 mx2_x2
xsubckt_3302_mx2_x2 0 4669 1 705 1151 991 mx2_x2
xsubckt_2996_o2_x2 0 4969 1 4970 4972 o2_x2
xsubckt_2584_nand4_x0 1 0 5373 5604 532 7689 54 nand4_x0
xcmpt_zero_59 1 0 279 zero_x1
xcmpt_zero_58 1 0 280 zero_x1
xcmpt_zero_57 1 0 281 zero_x1
xcmpt_zero_56 1 0 282 zero_x1
xcmpt_zero_55 1 0 284 zero_x1
xcmpt_zero_54 1 0 285 zero_x1
xcmpt_zero_53 1 0 286 zero_x1
xcmpt_zero_52 1 0 287 zero_x1
xcmpt_zero_51 1 0 288 zero_x1
xcmpt_zero_50 1 0 289 zero_x1
xsubckt_1628_nand2_x0 1 0 6213 6215 6218 nand2_x0
xsubckt_1652_oa22_x2 0 6189 1 6192 6195 6335 oa22_x2
xsubckt_9892_sff1_x4 1 1872 0 8584 1618 sff1_x4
xsubckt_9457_sff1_x4 1 1872 0 9009 1403 sff1_x4
xsubckt_7690_nand2_x0 1 0 7841 646 600 nand2_x0
xsubckt_7512_ao22_x2 0 7982 1 2857 2860 306 ao22_x2
xsubckt_3393_mx3_x2 1 0 4579 704 7218 4580 4598 4613 mx3_x2
xsubckt_3308_mx2_x2 0 4663 1 707 4664 4665 mx2_x2
xsubckt_3264_mx2_x2 0 4706 1 705 1728 896 mx2_x2
xsubckt_111_inv_x0 1 0 644 7680 inv_x0
xsubckt_500_inv_x0 1 0 396 7291 inv_x0
xsubckt_502_inv_x0 1 0 395 7289 inv_x0
xsubckt_504_inv_x0 1 0 385 7287 inv_x0
xsubckt_1434_nand4_x0 1 0 6407 6408 6413 6420 6426 nand4_x0
xsubckt_9814_sff1_x4 1 1872 0 8662 1665 sff1_x4
xsubckt_8992_sff1_x4 1 1872 0 9433 509 sff1_x4
xsubckt_8557_sff1_x4 1 1872 0 9836 1493 sff1_x4
xsubckt_7749_mx3_x2 1 0 9118 7828 3897 1033 3863 3864 mx3_x2
xsubckt_7747_mx3_x2 1 0 9120 7828 3897 1035 3871 3872 mx3_x2
xsubckt_7586_ao22_x2 0 9182 1 7956 7926 7928 ao22_x2
xsubckt_7332_nand2_x0 1 0 8073 8076 8133 nand2_x0
xsubckt_5834_nand3_x0 1 0 2792 2793 2798 7628 nand3_x0
xsubckt_5790_ao22_x2 0 2833 1 2843 2836 2834 ao22_x2
xsubckt_4691_oa22_x2 0 3723 1 3726 1803 1802 oa22_x2
xsubckt_3791_oa22_x2 0 4188 1 4189 705 7218 oa22_x2
xsubckt_3463_nand2_x0 1 0 4511 4512 7219 nand2_x0
xsubckt_3356_oa22_x2 0 4616 1 1150 7217 4617 oa22_x2
xsubckt_3268_mx2_x2 0 4702 1 705 768 1632 mx2_x2
xsubckt_3266_mx2_x2 0 4704 1 7219 4705 4706 mx2_x2
xsubckt_2847_nand3_x0 1 0 5115 5116 5268 7104 nand3_x0
xsubckt_2731_mx2_x2 0 5229 1 706 1196 1132 mx2_x2
xsubckt_117_inv_x0 1 0 532 7674 inv_x0
xsubckt_115_inv_x0 1 0 533 7676 inv_x0
xsubckt_113_inv_x0 1 0 308 7678 inv_x0
xcmpt_zero_69 1 0 39 zero_x1
xcmpt_zero_68 1 0 174 zero_x1
xcmpt_zero_67 1 0 270 zero_x1
xcmpt_zero_66 1 0 271 zero_x1
xcmpt_zero_65 1 0 273 zero_x1
xcmpt_zero_64 1 0 274 zero_x1
xcmpt_zero_63 1 0 275 zero_x1
xcmpt_zero_62 1 0 276 zero_x1
xcmpt_zero_61 1 0 277 zero_x1
xcmpt_zero_60 1 0 278 zero_x1
xsubckt_460_inv_x0 1 0 101 7331 inv_x0
xsubckt_506_inv_x0 1 0 202 7285 inv_x0
xsubckt_508_inv_x0 1 0 380 7283 inv_x0
xsubckt_9888_sff1_x4 1 1872 0 8588 1622 sff1_x4
xsubckt_9365_sff1_x4 1 1872 0 9096 1039 sff1_x4
xsubckt_8988_sff1_x4 1 1872 0 9437 513 sff1_x4
xsubckt_8914_sff1_x4 1 1872 0 9479 1845 sff1_x4
xsubckt_7390_a4_x2 0 8028 1 8029 8032 8036 7665 a4_x2
xsubckt_7242_nand2_x0 1 0 8139 7679 644 nand2_x0
xsubckt_7183_mx2_x2 0 9342 1 8157 3894 1160 mx2_x2
xsubckt_6536_nand3_x0 1 0 2109 2110 2111 7613 nand3_x0
xsubckt_6434_mx3_x2 1 0 2209 712 710 2210 1247 1407 mx3_x2
xsubckt_6432_mx3_x2 1 0 2211 712 710 2212 959 1119 mx3_x2
xsubckt_5786_ao22_x2 0 2837 1 7684 7106 2838 ao22_x2
xsubckt_5111_a3_x2 1 3391 0 40 111 7780 a3_x2
xsubckt_4812_ao22_x2 0 3626 1 1776 3629 40 ao22_x2
xsubckt_4125_nxr2_x1 3868 1 0 3873 7728 nxr2_x1
xsubckt_3713_oa22_x2 0 4265 1 4333 4328 4331 oa22_x2
xsubckt_3373_nand2_x0 1 0 4599 4600 4603 nand2_x0
xsubckt_2733_mx2_x2 0 5227 1 706 1068 972 mx2_x2
xsubckt_2581_nand2_x0 1 0 5376 7152 7290 nand2_x0
xsubckt_2456_oa22_x2 0 5499 1 5500 5503 7219 oa22_x2
xsubckt_1072_nxr2_x1 6751 1 0 696 71 nxr2_x1
xsubckt_787_oa22_x2 0 7023 1 7041 7126 7642 oa22_x2
xsubckt_119_inv_x0 1 0 665 7672 inv_x0
xsubckt_462_inv_x0 1 0 100 7329 inv_x0
xsubckt_464_inv_x0 1 0 99 7327 inv_x0
xsubckt_466_inv_x0 1 0 98 7325 inv_x0
xsubckt_1178_nand2_x0 1 0 6650 1824 589 nand2_x0
xsubckt_1398_ao22_x2 0 6442 1 6444 6445 1740 ao22_x2
xsubckt_1875_nand3_x0 1 0 5980 5981 5982 5983 nand3_x0
xsubckt_9722_sff1_x4 1 1872 0 8754 765 sff1_x4
xsubckt_8822_sff1_x4 1 1872 0 9571 54 sff1_x4
xsubckt_8465_sff1_x4 1 1872 0 9928 720 sff1_x4
xsubckt_7189_mx2_x2 0 9336 1 8157 3874 1132 mx2_x2
xsubckt_7187_mx2_x2 0 9338 1 8157 3882 1134 mx2_x2
xsubckt_7185_mx2_x2 0 9340 1 8157 3890 1148 mx2_x2
xsubckt_7062_nand2_x0 1 0 8238 8239 712 nand2_x0
xsubckt_6650_mx2_x2 0 1997 1 710 1722 890 mx2_x2
xsubckt_5572_a4_x2 0 2991 1 2999 1841 1842 1843 a4_x2
xsubckt_4711_a3_x2 1 3704 0 3718 3745 1801 a3_x2
xsubckt_3105_nand2_x0 1 0 4862 4863 7219 nand2_x0
xsubckt_1033_oa22_x2 0 6788 1 525 6899 6789 oa22_x2
xcmpt_zero_79 1 0 37 zero_x1
xcmpt_zero_78 1 0 4 zero_x1
xcmpt_zero_77 1 0 5 zero_x1
xcmpt_zero_76 1 0 6 zero_x1
xcmpt_zero_75 1 0 7 zero_x1
xcmpt_zero_74 1 0 8 zero_x1
xcmpt_zero_73 1 0 9 zero_x1
xcmpt_zero_72 1 0 16 zero_x1
xcmpt_zero_71 1 0 27 zero_x1
xcmpt_zero_70 1 0 38 zero_x1
xsubckt_468_inv_x0 1 0 97 7323 inv_x0
xsubckt_1991_oa22_x2 0 5875 1 6397 5885 6164 oa22_x2
xsubckt_9796_sff1_x4 1 1872 0 8680 1682 sff1_x4
xsubckt_9718_sff1_x4 1 1872 0 8758 769 sff1_x4
xsubckt_9273_sff1_x4 1 1872 0 9188 680 sff1_x4
xsubckt_8896_sff1_x4 1 1872 0 9497 1865 sff1_x4
xsubckt_8373_sff1_x4 1 1872 0 10012 1574 sff1_x4
xsubckt_7648_oa22_x2 0 7875 1 644 7679 699 oa22_x2
xsubckt_7331_a2_x2 0 8074 1 8076 8133 a2_x2
xsubckt_7136_a2_x2 0 8168 1 8169 40 a2_x2
xsubckt_6797_nand2_x0 1 0 8497 8498 2729 nand2_x0
xsubckt_6207_a2_x2 0 9401 1 2431 2481 a2_x2
xsubckt_5907_mx3_x2 1 0 2724 712 710 2725 1229 1389 mx3_x2
xsubckt_5905_mx3_x2 1 0 2726 712 710 2727 941 1101 mx3_x2
xsubckt_4604_a2_x2 0 3765 1 3766 3796 a2_x2
xsubckt_2887_oa22_x2 0 5076 1 5078 5081 7215 oa22_x2
xsubckt_2512_a2_x2 0 5444 1 5445 704 a2_x2
xsubckt_1031_mx2_x2 0 6790 1 7685 6959 7678 mx2_x2
xsubckt_747_nand2_x0 1 0 7058 7059 7061 nand2_x0
xsubckt_738_o2_x2 0 7066 1 7067 7119 o2_x2
xsubckt_1603_a2_x2 0 6238 1 197 227 a2_x2
xsubckt_2133_nand2_x0 1 0 428 5761 5788 nand2_x0
xsubckt_9630_sff1_x4 1 1872 0 8843 853 sff1_x4
xsubckt_9269_sff1_x4 1 1872 0 9192 520 sff1_x4
xsubckt_8818_sff1_x4 1 1872 0 9575 1748 sff1_x4
xsubckt_8730_sff1_x4 1 1872 0 9663 1259 sff1_x4
xsubckt_7625_a2_x2 0 7894 1 653 600 a2_x2
xsubckt_7371_a2_x2 0 8045 1 8138 609 a2_x2
xsubckt_6529_nand2_x0 1 0 2116 7476 710 nand2_x0
xsubckt_6267_a2_x2 0 2372 1 7506 710 a2_x2
xsubckt_6086_nand3_x0 1 0 2549 2550 2551 7613 nand3_x0
xsubckt_5859_nor2_x0 1 0 2768 2769 711 nor2_x0
xsubckt_5807_a2_x2 0 2819 1 7615 710 a2_x2
xsubckt_5553_a2_x2 0 9481 1 3005 3006 a2_x2
xsubckt_5364_nxr2_x1 3157 1 0 3469 665 nxr2_x1
xsubckt_4794_ao22_x2 0 3640 1 1780 3642 40 ao22_x2
xsubckt_4079_nor2_x0 1 0 3906 523 522 nor2_x0
xsubckt_3695_oa22_x2 0 4282 1 4283 4292 704 oa22_x2
xsubckt_2806_a2_x2 0 5155 1 5156 5162 a2_x2
xsubckt_973_o2_x2 0 6845 1 6846 6847 o2_x2
xcmpt_zero_80 1 0 36 zero_x1
xcmpt_zero_81 1 0 35 zero_x1
xcmpt_zero_82 1 0 34 zero_x1
xcmpt_zero_83 1 0 33 zero_x1
xcmpt_zero_84 1 0 32 zero_x1
xcmpt_zero_85 1 0 31 zero_x1
xcmpt_zero_86 1 0 30 zero_x1
xcmpt_zero_87 1 0 29 zero_x1
xcmpt_zero_88 1 0 28 zero_x1
xcmpt_zero_89 1 0 26 zero_x1
xsubckt_1499_nxr2_x1 6342 1 0 189 219 nxr2_x1
xsubckt_1623_a2_x2 0 6218 1 6219 6323 a2_x2
xsubckt_1663_a2_x2 0 6178 1 7226 217 a2_x2
xsubckt_1909_oa22_x2 0 5950 1 5951 6357 574 oa22_x2
xsubckt_9626_sff1_x4 1 1872 0 8847 857 sff1_x4
xsubckt_9181_sff1_x4 1 1872 0 9277 578 sff1_x4
xsubckt_9103_sff1_x4 1 1872 0 1925 1893 sff1_x4
xsubckt_8369_sff1_x4 1 1872 0 10016 1548 sff1_x4
xsubckt_7033_oa22_x2 0 8267 1 8268 710 711 oa22_x2
xsubckt_6960_nand2_x0 1 0 8338 8339 712 nand2_x0
xsubckt_5900_nand2_x0 1 0 9408 2731 2733 nand2_x0
xsubckt_5847_a2_x2 0 2780 1 2781 7631 a2_x2
xsubckt_4201_mx3_x2 1 0 10028 3899 3896 1589 3811 3813 mx3_x2
xsubckt_3971_nor2_x0 1 0 10057 4012 4067 nor2_x0
xsubckt_1778_nand2_x0 1 0 6068 6116 6287 nand2_x0
xsubckt_1895_oa22_x2 0 1928 1 6111 5967 5963 oa22_x2
xsubckt_2039_nand3_x0 1 0 5830 5831 5832 5833 nand3_x0
xsubckt_9177_sff1_x4 1 1872 0 9281 582 sff1_x4
xsubckt_8726_sff1_x4 1 1872 0 9667 1265 sff1_x4
xsubckt_7565_o3_x2 0 7941 1 7942 7952 7955 o3_x2
xsubckt_6259_nand2_x0 1 0 2380 2381 2382 nand2_x0
xsubckt_6215_o2_x2 0 2423 1 2424 711 o2_x2
xsubckt_5738_mx2_x2 0 9445 1 2856 456 493 mx2_x2
xsubckt_5467_nand2_x0 1 0 3067 3070 7284 nand2_x0
xsubckt_4945_mx3_x2 1 0 3526 5754 518 7756 7346 7347 mx3_x2
xsubckt_4941_mx3_x2 1 0 3529 5754 518 7755 7348 7349 mx3_x2
xsubckt_4818_o3_x2 0 3621 1 3627 3631 7712 o3_x2
xsubckt_4552_mx3_x2 1 0 9718 3771 3896 1440 3841 3843 mx3_x2
xsubckt_4550_mx3_x2 1 0 9720 3771 3896 1442 3847 3849 mx3_x2
xsubckt_4209_mx3_x2 1 0 10026 3899 3896 1587 3805 3807 mx3_x2
xsubckt_4205_mx3_x2 1 0 10027 3899 3896 1588 3808 3810 mx3_x2
xsubckt_4161_mx3_x2 1 0 10038 3899 3896 1600 3841 3843 mx3_x2
xcmpt_zero_90 1 0 25 zero_x1
xcmpt_zero_91 1 0 24 zero_x1
xcmpt_zero_92 1 0 23 zero_x1
xcmpt_zero_93 1 0 22 zero_x1
xcmpt_zero_94 1 0 21 zero_x1
xcmpt_zero_95 1 0 20 zero_x1
xcmpt_zero_96 1 0 19 zero_x1
xcmpt_zero_97 1 0 18 zero_x1
xcmpt_zero_98 1 0 17 zero_x1
xcmpt_zero_99 1 0 15 zero_x1
xsubckt_31_inv_x0 1 0 137 7760 inv_x0
xsubckt_33_inv_x0 1 0 109 7758 inv_x0
xsubckt_2268_oa22_x2 0 5684 1 5685 710 7631 oa22_x2
xsubckt_9534_sff1_x4 1 1872 0 10104 1742 sff1_x4
xsubckt_9011_sff1_x4 1 1872 0 9414 483 sff1_x4
xsubckt_7585_o3_x2 0 7926 1 7927 7952 7955 o3_x2
xsubckt_7464_oa22_x2 0 7996 1 7783 7208 2 oa22_x2
xsubckt_7304_nand2_x0 1 0 8094 8095 8136 nand2_x0
xsubckt_7029_oa22_x2 0 8271 1 8272 710 7628 oa22_x2
xsubckt_6549_o2_x2 0 2096 1 733 710 o2_x2
xsubckt_5955_ao22_x2 0 2677 1 716 710 712 ao22_x2
xsubckt_5716_nand3_x0 1 0 2875 2876 2881 703 nand3_x0
xsubckt_5233_oa22_x2 0 3278 1 7102 3283 3279 oa22_x2
xsubckt_4949_mx3_x2 1 0 3523 5754 518 7757 7344 7345 mx3_x2
xsubckt_4558_mx3_x2 1 0 9712 3771 3896 1433 3823 3825 mx3_x2
xsubckt_4556_mx3_x2 1 0 9714 3771 3896 1435 3829 3831 mx3_x2
xsubckt_4554_mx3_x2 1 0 9716 3771 3896 1438 3835 3837 mx3_x2
xsubckt_4165_mx3_x2 1 0 10037 3899 3896 1599 3838 3840 mx3_x2
xsubckt_4030_mx2_x2 0 3954 1 705 1424 1264 mx2_x2
xsubckt_3525_nand2_x0 1 0 4450 4451 7219 nand2_x0
xsubckt_798_ao22_x2 0 7012 1 701 76 1740 ao22_x2
xsubckt_599_oa22_x2 0 7192 1 7194 40 7782 oa22_x2
xsubckt_35_inv_x0 1 0 111 7756 inv_x0
xsubckt_37_inv_x0 1 0 113 7754 inv_x0
xsubckt_39_inv_x0 1 0 117 7752 inv_x0
xsubckt_1851_nand2_x0 1 0 6002 6116 6318 nand2_x0
xsubckt_9085_sff1_x4 1 1872 0 1935 1903 sff1_x4
xsubckt_8634_sff1_x4 1 1872 0 9759 1067 sff1_x4
xsubckt_8128_mx3_x2 1 0 8699 7804 3897 1702 3859 3860 mx3_x2
xsubckt_8126_mx3_x2 1 0 8701 7804 3897 1674 3867 3868 mx3_x2
xsubckt_8080_mx3_x2 1 0 8775 7808 3896 784 3799 3801 mx3_x2
xsubckt_7663_ao22_x2 0 9168 1 7866 7863 7864 ao22_x2
xsubckt_6332_nand2_x0 1 0 2308 2309 7620 nand2_x0
xsubckt_6079_nand2_x0 1 0 2556 7538 710 nand2_x0
xsubckt_5229_oa22_x2 0 3282 1 7680 3499 7167 oa22_x2
xsubckt_5197_nand2_x0 1 0 9530 3312 3323 nand2_x0
xsubckt_4169_mx3_x2 1 0 10036 3899 3896 1598 3835 3837 mx3_x2
xsubckt_4036_mx2_x2 0 3948 1 705 1712 880 mx2_x2
xsubckt_3801_nor2_x0 1 0 4178 4179 5585 nor2_x0
xsubckt_3798_ao22_x2 0 4181 1 7218 4182 703 ao22_x2
xsubckt_3345_nand2_x0 1 0 4627 705 1534 nand2_x0
xsubckt_2639_nand3_x0 1 0 5319 5320 5321 7104 nand3_x0
xsubckt_607_a4_x2 0 7184 1 7186 7187 7190 7784 a4_x2
xsubckt_1567_ao22_x2 0 6274 1 230 7253 6276 ao22_x2
xsubckt_1671_nand2_x0 1 0 6170 6171 6173 nand2_x0
xsubckt_1924_ao22_x2 0 5936 1 5940 5939 5937 ao22_x2
xsubckt_9442_sff1_x4 1 1872 0 9024 1389 sff1_x4
xsubckt_9007_sff1_x4 1 1872 0 9418 492 sff1_x4
xsubckt_7940_mx3_x2 1 0 8907 7816 3896 1205 3811 3813 mx3_x2
xsubckt_7659_ao22_x2 0 7866 1 7953 8018 355 ao22_x2
xsubckt_7379_nor2_x0 1 0 8039 360 359 nor2_x0
xsubckt_7204_mx3_x2 1 0 9321 8158 3896 1146 3826 3828 mx3_x2
xsubckt_7202_mx3_x2 1 0 9323 8158 3896 1149 3832 3834 mx3_x2
xsubckt_7200_mx3_x2 1 0 9325 8158 3896 1151 3838 3840 mx3_x2
xsubckt_5536_nand3_x0 1 0 3017 3023 1852 1853 nand3_x0
xsubckt_4764_oa22_x2 0 3663 1 3667 1789 1788 oa22_x2
xsubckt_4654_nand3_x0 1 0 3751 3754 3763 1773 nand3_x0
xsubckt_3862_nand3_x0 1 0 4118 4119 4120 4122 nand3_x0
xsubckt_3850_mx2_x2 0 4130 1 705 1493 1333 mx2_x2
xsubckt_3114_mx2_x2 0 4853 1 705 1219 1091 mx2_x2
xsubckt_3112_mx2_x2 0 4855 1 705 1155 995 mx2_x2
xsubckt_809_nand2_x0 1 0 7002 690 65 nand2_x0
xsubckt_1403_nand2_x0 1 0 6437 1811 589 nand2_x0
xsubckt_9438_sff1_x4 1 1872 0 9028 1415 sff1_x4
xsubckt_8542_sff1_x4 1 1872 0 9851 1509 sff1_x4
xsubckt_7944_mx3_x2 1 0 8903 7816 3896 1200 3799 3801 mx3_x2
xsubckt_7942_mx3_x2 1 0 8905 7816 3896 1203 3805 3807 mx3_x2
xsubckt_7813_mx2_x2 0 9028 1 7821 3892 1415 mx2_x2
xsubckt_7420_mx2_x2 0 9088 1 7199 380 348 mx2_x2
xsubckt_7208_mx3_x2 1 0 9317 8158 3896 1142 3814 3816 mx3_x2
xsubckt_7206_mx3_x2 1 0 9319 8158 3896 1144 3820 3822 mx3_x2
xsubckt_7162_mx3_x2 1 0 9354 8167 3896 1305 3823 3825 mx3_x2
xsubckt_7160_mx3_x2 1 0 9356 8167 3896 1307 3829 3831 mx3_x2
xsubckt_3864_oa22_x2 0 4116 1 7179 4158 4117 oa22_x2
xsubckt_3852_mx2_x2 0 4128 1 704 4129 4131 mx2_x2
xsubckt_3116_mx2_x2 0 4851 1 706 4852 4854 mx2_x2
xsubckt_3075_nand2_x0 1 0 4891 7153 7276 nand2_x0
xsubckt_608_a2_x2 0 7183 1 1737 483 a2_x2
xsubckt_310_inv_x0 1 0 1118 7481 inv_x0
xsubckt_1195_nor2_x0 1 0 6634 6637 7791 nor2_x0
xsubckt_1313_nand2_x0 1 0 6522 1817 589 nand2_x0
xsubckt_1491_nand2_x0 1 0 6350 192 222 nand2_x0
xsubckt_9873_sff1_x4 1 1872 0 8603 1638 sff1_x4
xsubckt_9350_sff1_x4 1 1872 0 9111 1056 sff1_x4
xsubckt_8973_sff1_x4 1 1872 0 152 89 sff1_x4
xsubckt_8538_sff1_x4 1 1872 0 9855 1483 sff1_x4
xsubckt_8450_sff1_x4 1 1872 0 9943 737 sff1_x4
xsubckt_8253_nand3_x0 1 0 7795 7796 2858 7201 nand3_x0
xsubckt_7817_mx2_x2 0 9024 1 7821 3878 1389 mx2_x2
xsubckt_7815_mx2_x2 0 9026 1 7821 3886 1393 mx2_x2
xsubckt_7426_mx2_x2 0 9085 1 7199 407 375 mx2_x2
xsubckt_7424_mx2_x2 0 9086 1 7199 378 346 mx2_x2
xsubckt_7422_mx2_x2 0 9087 1 7199 379 347 mx2_x2
xsubckt_7280_oa22_x2 0 9301 1 8111 8116 8118 oa22_x2
xsubckt_7166_mx3_x2 1 0 9350 8167 3896 1301 3811 3813 mx3_x2
xsubckt_7164_mx3_x2 1 0 9352 8167 3896 1303 3817 3819 mx3_x2
xsubckt_7035_mx2_x2 0 8265 1 710 1680 1552 mx2_x2
xsubckt_5336_ao22_x2 0 3183 1 600 3184 644 ao22_x2
xsubckt_4184_nxr2_x1 3823 1 0 3827 7741 nxr2_x1
xsubckt_4110_nxr2_x1 3880 1 0 3885 7725 nxr2_x1
xsubckt_3469_mx2_x2 0 4505 1 7217 7463 7467 mx2_x2
xsubckt_2716_mx3_x2 1 0 5244 707 705 5245 1292 1452 mx3_x2
xsubckt_2529_oa22_x2 0 5427 1 5428 5430 703 oa22_x2
xsubckt_1077_nor3_x0 1 0 6746 403 308 307 nor3_x0
xsubckt_639_nor4_x0 1 0 7156 599 583 573 597 nor4_x0
xsubckt_312_inv_x0 1 0 1373 7479 inv_x0
xsubckt_314_inv_x0 1 0 861 7477 inv_x0
xsubckt_316_inv_x0 1 0 1597 7475 inv_x0
xsubckt_2015_nand2_x0 1 0 1917 5853 5857 nand2_x0
xsubckt_9869_sff1_x4 1 1872 0 8607 1612 sff1_x4
xsubckt_9781_sff1_x4 1 1872 0 8695 1698 sff1_x4
xsubckt_9346_sff1_x4 1 1872 0 9115 1060 sff1_x4
xsubckt_7775_mx2_x2 0 9062 1 7825 3892 1383 mx2_x2
xsubckt_7644_nor2_x0 1 0 7878 7879 7880 nor2_x0
xsubckt_7428_mx2_x2 0 9084 1 7199 406 374 mx2_x2
xsubckt_7168_mx3_x2 1 0 9348 8167 3896 1299 3805 3807 mx3_x2
xsubckt_4326_a4_x2 0 3787 1 3902 7168 523 522 a4_x2
xsubckt_3536_ao22_x2 0 4439 1 4444 4442 4440 ao22_x2
xsubckt_2936_mx2_x2 0 5028 1 707 1734 1382 mx2_x2
xsubckt_2934_mx2_x2 0 5030 1 705 5031 5032 mx2_x2
xsubckt_2932_mx2_x2 0 5032 1 707 838 806 mx2_x2
xsubckt_2674_mx3_x2 1 0 5285 703 7218 5286 5287 5289 mx3_x2
xsubckt_2672_mx3_x2 1 0 5287 707 705 5288 7569 7571 mx3_x2
xsubckt_971_ao22_x2 0 6847 1 6848 6852 7038 ao22_x2
xsubckt_880_nand2_x0 1 0 6934 588 1762 nand2_x0
xsubckt_270_inv_x0 1 0 1541 7521 inv_x0
xsubckt_272_inv_x0 1 0 1189 7519 inv_x0
xsubckt_274_inv_x0 1 0 1061 7517 inv_x0
xsubckt_318_inv_x0 1 0 1213 7473 inv_x0
xsubckt_1460_nor2_x0 1 0 6381 6382 6407 nor2_x0
xsubckt_9703_sff1_x4 1 1872 0 8773 776 sff1_x4
xsubckt_8969_sff1_x4 1 1872 0 156 93 sff1_x4
xsubckt_8881_sff1_x4 1 1872 0 9512 115 sff1_x4
xsubckt_8446_sff1_x4 1 1872 0 9947 741 sff1_x4
xsubckt_7779_mx2_x2 0 9058 1 7825 3878 1357 mx2_x2
xsubckt_7777_mx2_x2 0 9060 1 7825 3886 1361 mx2_x2
xsubckt_7387_a4_x2 0 8031 1 7669 7670 353 352 a4_x2
xsubckt_6928_nand3_x0 1 0 8369 8370 8377 7613 nand3_x0
xsubckt_6111_mx2_x2 0 2524 1 710 1129 969 mx2_x2
xsubckt_5960_nand2_x0 1 0 2672 2673 2678 nand2_x0
xsubckt_5148_a3_x2 1 3357 0 40 138 7780 a3_x2
xsubckt_4900_nand2_x0 1 0 3559 3562 1753 nand2_x0
xsubckt_3613_nor2_x0 1 0 4363 4364 7219 nor2_x0
xsubckt_3234_nand3_x0 1 0 4735 4736 4893 7104 nand3_x0
xsubckt_2938_mx2_x2 0 5026 1 706 5027 5030 mx2_x2
xsubckt_2892_mx2_x2 0 5071 1 705 1193 1065 mx2_x2
xsubckt_2549_mx2_x2 0 5408 1 705 1201 1073 mx2_x2
xsubckt_1012_a2_x2 0 6808 1 227 1739 a2_x2
xsubckt_790_nand2_x0 1 0 7020 587 1780 nand2_x0
xsubckt_588_o3_x2 0 7203 1 482 483 481 o3_x2
xsubckt_276_inv_x0 1 0 1540 7515 inv_x0
xsubckt_278_inv_x0 1 0 1379 7513 inv_x0
xsubckt_1972_oa22_x2 0 5892 1 5893 6172 7788 oa22_x2
xsubckt_9777_sff1_x4 1 1872 0 8699 1702 sff1_x4
xsubckt_9254_sff1_x4 1 1872 0 9207 324 sff1_x4
xsubckt_8803_sff1_x4 1 1872 0 9590 1765 sff1_x4
xsubckt_7054_a2_x2 0 8246 1 7384 710 a2_x2
xsubckt_6855_mx2_x2 0 8441 1 712 1205 1173 mx2_x2
xsubckt_6853_mx2_x2 0 8443 1 712 981 949 mx2_x2
xsubckt_6851_mx2_x2 0 8445 1 712 1141 1109 mx2_x2
xsubckt_6508_mx2_x2 0 2136 1 710 1726 894 mx2_x2
xsubckt_6460_mx2_x2 0 2183 1 710 1503 1343 mx2_x2
xsubckt_5637_a3_x2 1 9458 0 2944 2945 40 a3_x2
xsubckt_4903_a3_x2 1 3557 0 3562 1753 1752 a3_x2
xsubckt_4708_a3_x2 1 3707 0 3708 3709 3722 a3_x2
xsubckt_4467_nand2_x0 1 0 3774 3780 3900 nand2_x0
xsubckt_4327_a2_x2 0 3786 1 3787 3907 a2_x2
xsubckt_2898_mx2_x2 0 5065 1 705 745 1609 mx2_x2
xsubckt_2896_mx2_x2 0 5067 1 705 1673 1545 mx2_x2
xsubckt_2615_nand2_x0 1 0 5343 5344 5345 nand2_x0
xsubckt_1501_a2_x2 0 6340 1 190 220 a2_x2
xsubckt_1521_a2_x2 0 6320 1 196 226 a2_x2
xsubckt_9611_sff1_x4 1 1872 0 8862 843 sff1_x4
xsubckt_8877_sff1_x4 1 1872 0 9516 120 sff1_x4
xsubckt_8354_sff1_x4 1 1872 0 10031 1592 sff1_x4
xsubckt_7629_oa22_x2 0 7891 1 644 7679 696 oa22_x2
xsubckt_7541_oa22_x2 0 7961 1 7970 7093 7209 oa22_x2
xsubckt_7368_a2_x2 0 8047 1 8138 592 a2_x2
xsubckt_7364_nand2_x0 1 0 9278 8050 8052 nand2_x0
xsubckt_7094_a2_x2 0 8207 1 8208 8210 a2_x2
xsubckt_6857_mx2_x2 0 8439 1 712 1077 1045 mx2_x2
xsubckt_6599_mx3_x2 1 0 2047 712 710 2048 859 1371 mx3_x2
xsubckt_6185_a2_x2 0 2452 1 7522 710 a2_x2
xsubckt_6077_mx2_x2 0 2558 1 710 1001 809 mx2_x2
xsubckt_6075_mx2_x2 0 2560 1 710 1481 1321 mx2_x2
xsubckt_5931_mx2_x2 0 2700 1 709 2701 2704 mx2_x2
xsubckt_5690_nand2_x0 1 0 2901 2902 2903 nand2_x0
xsubckt_5395_nor2_x0 1 0 3128 3129 3130 nor2_x0
xsubckt_5310_oa22_x2 0 9521 1 3208 3209 3218 oa22_x2
xsubckt_5259_nand2_x0 1 0 9525 3255 3265 nand2_x0
xsubckt_4748_a3_x2 1 3676 0 1794 1793 1791 a3_x2
xsubckt_4720_nand2_x0 1 0 3697 3701 1799 nand2_x0
xsubckt_3495_nand2_x0 1 0 4479 7153 7267 nand2_x0
xsubckt_1541_a2_x2 0 6300 1 417 201 a2_x2
xsubckt_1561_a2_x2 0 6280 1 7252 229 a2_x2
xsubckt_1733_nand2_x0 1 0 6108 6114 6140 nand2_x0
xsubckt_1813_nor2_x0 1 0 6037 6243 6303 nor2_x0
xsubckt_1819_nand3_x0 1 0 6031 6032 6033 6111 nand3_x0
xsubckt_1997_nand3_x0 1 0 5869 5870 5871 6111 nand3_x0
xsubckt_2275_a2_x2 0 5677 1 5678 5683 a2_x2
xsubckt_9685_sff1_x4 1 1872 0 8791 802 sff1_x4
xsubckt_9162_sff1_x4 1 1872 0 9296 595 sff1_x4
xsubckt_8711_sff1_x4 1 1872 0 9682 1115 sff1_x4
xsubckt_6499_a2_x2 0 2145 1 7489 710 a2_x2
xsubckt_5422_nand2_x0 1 0 3103 3456 665 nand2_x0
xsubckt_4019_nand2_x0 1 0 3964 3965 3971 nand2_x0
xsubckt_2744_a2_x2 0 5216 1 5217 5236 a2_x2
xsubckt_2699_nand3_x0 1 0 5260 5261 5269 5304 nand3_x0
xsubckt_1639_nand3_x0 1 0 6202 6325 7244 224 nand3_x0
xsubckt_1802_oa22_x2 0 1907 1 6051 6050 6047 oa22_x2
xsubckt_9607_sff1_x4 1 1872 0 8866 849 sff1_x4
xsubckt_8785_sff1_x4 1 1872 0 9608 1785 sff1_x4
xsubckt_8707_sff1_x4 1 1872 0 9686 1120 sff1_x4
xsubckt_5949_nand2_x0 1 0 2683 2684 7631 nand2_x0
xsubckt_5939_mx2_x2 0 2693 1 712 972 940 mx2_x2
xsubckt_5253_nxr2_x1 3260 1 0 3261 3264 nxr2_x1
xsubckt_4683_ao22_x2 0 3729 1 1804 3731 40 ao22_x2
xsubckt_4360_mx3_x2 1 0 9895 3786 3896 1519 3797 3798 mx3_x2
xsubckt_3980_nxr2_x1 4003 1 0 4004 4010 nxr2_x1
xsubckt_1876_oa22_x2 0 1930 1 6111 5984 5980 oa22_x2
xsubckt_9593_sff1_x4 1 1872 0 8880 922 sff1_x4
xsubckt_9515_sff1_x4 1 1872 0 8951 962 sff1_x4
xsubckt_9158_sff1_x4 1 1872 0 9300 598 sff1_x4
xsubckt_9070_sff1_x4 1 1872 0 9356 1307 sff1_x4
xsubckt_8693_sff1_x4 1 1872 0 9700 1116 sff1_x4
xsubckt_7609_nand4_x0 1 0 7907 7908 7951 7957 8140 nand4_x0
xsubckt_7287_ao22_x2 0 8106 1 645 7680 593 ao22_x2
xsubckt_6868_o3_x2 0 8428 1 8429 8430 7620 o3_x2
xsubckt_6622_o2_x2 0 2025 1 2026 2028 o2_x2
xsubckt_6034_nand2_x0 1 0 2600 2601 2602 nand2_x0
xsubckt_5292_oa22_x2 0 3224 1 3241 3239 3240 oa22_x2
xsubckt_4679_ao22_x2 0 3732 1 1805 3734 40 ao22_x2
xsubckt_4211_nor3_x0 1 0 3803 3809 7747 7748 nor3_x0
xsubckt_3941_oa22_x2 0 4041 1 7219 4042 704 oa22_x2
xsubckt_779_nand2_x0 1 0 7030 702 1740 nand2_x0
xsubckt_2249_oa22_x2 0 5702 1 5704 5717 5744 oa22_x2
xsubckt_9589_sff1_x4 1 1872 0 8884 927 sff1_x4
xsubckt_9066_sff1_x4 1 1872 0 9360 1312 sff1_x4
xsubckt_8615_sff1_x4 1 1872 0 9778 1467 sff1_x4
xsubckt_5062_nand2_x0 1 0 3436 3538 7649 nand2_x0
xsubckt_2597_o2_x2 0 5361 1 204 676 o2_x2
xsubckt_1015_nand2_x0 1 0 6805 1833 589 nand2_x0
xsubckt_1622_nand3_x0 1 0 6219 6220 7242 226 nand3_x0
xsubckt_2075_nand2_x0 1 0 412 5799 7041 nand2_x0
xsubckt_9423_sff1_x4 1 1872 0 9043 1371 sff1_x4
xsubckt_8689_sff1_x4 1 1872 0 9704 1424 sff1_x4
xsubckt_8152_mx2_x2 0 8677 1 7801 3894 1672 mx2_x2
xsubckt_6309_ao22_x2 0 2331 1 2332 2334 2335 ao22_x2
xsubckt_5844_ao22_x2 0 2782 1 7612 7079 2783 ao22_x2
xsubckt_5122_oa22_x2 0 9536 1 3381 3382 3391 oa22_x2
xsubckt_4884_o2_x2 0 3571 1 3572 3631 o2_x2
xsubckt_3691_ao22_x2 0 4286 1 1240 7217 4287 ao22_x2
xsubckt_3311_mx2_x2 0 4660 1 7219 4661 4662 mx2_x2
xsubckt_3030_nand2_x0 1 0 4936 4937 7219 nand2_x0
xsubckt_762_nand2_x0 1 0 7046 7047 7048 nand2_x0
xsubckt_9497_sff1_x4 1 1872 0 8969 1171 sff1_x4
xsubckt_8523_sff1_x4 1 1872 0 9870 983 sff1_x4
xsubckt_8158_mx2_x2 0 8671 1 7801 3874 1644 mx2_x2
xsubckt_8156_mx2_x2 0 8673 1 7801 3882 1646 mx2_x2
xsubckt_8154_mx2_x2 0 8675 1 7801 3890 1660 mx2_x2
xsubckt_7752_mx3_x2 1 0 9115 7828 3896 1060 3853 3855 mx3_x2
xsubckt_7750_mx3_x2 1 0 9117 7828 3897 1062 3859 3860 mx3_x2
xsubckt_7694_nand2_x0 1 0 7838 8018 362 nand2_x0
xsubckt_5485_nand4_x0 1 0 3054 3063 1867 1868 1869 nand4_x0
xsubckt_5321_ao22_x2 0 3197 1 3204 3203 3200 ao22_x2
xsubckt_4693_nand4_x0 1 0 3721 3731 1804 1803 1802 nand4_x0
xsubckt_4064_ao22_x2 0 3920 1 3921 3923 3924 ao22_x2
xsubckt_3795_mx3_x2 1 0 4184 707 705 4185 1302 1462 mx3_x2
xsubckt_3317_mx2_x2 0 4654 1 707 4655 4656 mx2_x2
xsubckt_3315_mx2_x2 0 4656 1 705 1183 1055 mx2_x2
xsubckt_764_nor2_x0 1 0 7044 308 307 nor2_x0
xsubckt_758_nand3_x0 1 0 7050 308 7686 229 nand3_x0
xsubckt_672_nand2_x0 1 0 7123 7124 7130 nand2_x0
xsubckt_511_inv_x0 1 0 201 7280 inv_x0
xsubckt_9854_sff1_x4 1 1872 0 8622 1240 sff1_x4
xsubckt_9419_sff1_x4 1 1872 0 9047 1376 sff1_x4
xsubckt_9331_sff1_x4 1 1872 0 9130 1330 sff1_x4
xsubckt_8597_sff1_x4 1 1872 0 9796 1468 sff1_x4
xsubckt_7758_mx3_x2 1 0 9109 7828 3896 1054 3835 3837 mx3_x2
xsubckt_7756_mx3_x2 1 0 9111 7828 3896 1056 3841 3843 mx3_x2
xsubckt_7754_mx3_x2 1 0 9113 7828 3896 1058 3847 3849 mx3_x2
xsubckt_6895_nor2_x0 1 0 8401 8402 7134 nor2_x0
xsubckt_6652_ao22_x2 0 1995 1 2000 1998 1996 ao22_x2
xsubckt_5065_nxr2_x1 3433 1 0 3434 3437 nxr2_x1
xsubckt_3797_mx3_x2 1 0 4182 707 705 4183 1238 1398 mx3_x2
xsubckt_3666_mx2_x2 0 4311 1 706 1080 984 mx2_x2
xsubckt_3664_mx2_x2 0 4313 1 706 1208 1144 mx2_x2
xsubckt_2787_ao22_x2 0 5174 1 5176 5178 703 ao22_x2
xsubckt_761_a2_x2 0 7047 1 308 230 a2_x2
xsubckt_124_inv_x0 1 0 359 7667 inv_x0
xsubckt_122_inv_x0 1 0 356 7669 inv_x0
xsubckt_120_inv_x0 1 0 353 7671 inv_x0
xsubckt_513_inv_x0 1 0 199 7278 inv_x0
xsubckt_515_inv_x0 1 0 227 7276 inv_x0
xsubckt_1883_nand2_x0 1 0 5973 6114 6329 nand2_x0
xsubckt_2264_ao22_x2 0 5688 1 712 5693 5689 ao22_x2
xsubckt_8954_sff1_x4 1 1872 0 142 79 sff1_x4
xsubckt_8519_sff1_x4 1 1872 0 9874 987 sff1_x4
xsubckt_8431_sff1_x4 1 1872 0 9962 883 sff1_x4
xsubckt_4866_nand3_x0 1 0 3585 3591 1763 1761 nand3_x0
xsubckt_2814_nxr2_x1 5148 1 0 5149 5150 nxr2_x1
xsubckt_1172_nand3_x0 1 0 6656 6658 6675 6677 nand3_x0
xsubckt_128_inv_x0 1 0 650 7663 inv_x0
xsubckt_126_inv_x0 1 0 363 7665 inv_x0
xsubckt_471_inv_x0 1 0 1891 7320 inv_x0
xsubckt_473_inv_x0 1 0 1890 7318 inv_x0
xsubckt_517_inv_x0 1 0 225 7274 inv_x0
xsubckt_519_inv_x0 1 0 223 7272 inv_x0
xsubckt_1525_nand2_x0 1 0 6316 7241 227 nand2_x0
xsubckt_9762_sff1_x4 1 1872 0 8714 1716 sff1_x4
xsubckt_9327_sff1_x4 1 1872 0 9134 1334 sff1_x4
xsubckt_8427_sff1_x4 1 1872 0 9966 887 sff1_x4
xsubckt_7066_nand2_x0 1 0 8234 8235 7628 nand2_x0
xsubckt_6806_oa22_x2 0 8489 1 1558 710 712 oa22_x2
xsubckt_6725_nor2_x0 1 0 8568 8569 709 nor2_x0
xsubckt_6560_ao22_x2 0 2085 1 7625 957 2086 ao22_x2
xsubckt_6314_mx2_x2 0 2326 1 710 770 1634 mx2_x2
xsubckt_5984_oa22_x2 0 2649 1 1547 710 712 oa22_x2
xsubckt_4753_a4_x2 0 3672 1 1798 1797 1796 1792 a4_x2
xsubckt_3952_ao22_x2 0 4030 1 4031 4035 703 ao22_x2
xsubckt_3630_nand2_x0 1 0 4346 4347 4354 nand2_x0
xsubckt_3540_nand2_x0 1 0 4435 7218 858 nand2_x0
xsubckt_3517_ao22_x2 0 4458 1 7445 7217 7218 ao22_x2
xsubckt_2617_ao22_x2 0 5341 1 1230 7217 707 ao22_x2
xsubckt_475_inv_x0 1 0 1889 7316 inv_x0
xsubckt_477_inv_x0 1 0 1888 7314 inv_x0
xsubckt_479_inv_x0 1 0 1887 7312 inv_x0
xsubckt_1914_nxr2_x1 5945 1 0 5946 6337 nxr2_x1
xsubckt_9758_sff1_x4 1 1872 0 8718 1720 sff1_x4
xsubckt_8862_sff1_x4 1 1872 0 9531 136 sff1_x4
xsubckt_6799_nor2_x0 1 0 8495 8496 7134 nor2_x0
xsubckt_6663_mx2_x2 0 1985 1 712 1145 1113 mx2_x2
xsubckt_6270_mx2_x2 0 2369 1 710 771 1635 mx2_x2
xsubckt_6184_nand2_x0 1 0 2453 2454 711 nand2_x0
xsubckt_6033_ao22_x2 0 2601 1 7628 2606 708 ao22_x2
xsubckt_5892_oa22_x2 0 2736 1 690 7080 2737 oa22_x2
xsubckt_5535_a3_x2 1 3018 0 3023 1852 1853 a3_x2
xsubckt_5330_nxr2_x1 3189 1 0 3475 665 nxr2_x1
xsubckt_4848_ao22_x2 0 3599 1 1766 3601 40 ao22_x2
xsubckt_3749_oa22_x2 0 4229 1 4231 4234 7215 oa22_x2
xsubckt_3511_a2_x2 0 4464 1 4465 4466 a2_x2
xsubckt_3068_ao22_x2 0 4898 1 1252 7217 4899 ao22_x2
xsubckt_3042_a2_x2 0 4924 1 4925 7217 a2_x2
xsubckt_3019_nand2_x0 1 0 4946 4947 4954 nand2_x0
xsubckt_948_ao22_x2 0 6869 1 6870 6874 7038 ao22_x2
xsubckt_668_nor2_x0 1 0 7127 230 229 nor2_x0
xsubckt_1255_nand2_x0 1 0 6577 587 1756 nand2_x0
xsubckt_1465_nxr2_x1 6376 1 0 185 214 nxr2_x1
xsubckt_2137_nand2_x0 1 0 426 5759 5780 nand2_x0
xsubckt_2379_a3_x2 1 5575 0 5576 5579 7218 a3_x2
xsubckt_9670_sff1_x4 1 1872 0 8806 815 sff1_x4
xsubckt_9235_sff1_x4 1 1872 0 9226 314 sff1_x4
xsubckt_8858_sff1_x4 1 1872 0 9535 110 sff1_x4
xsubckt_8770_sff1_x4 1 1872 0 9623 1801 sff1_x4
xsubckt_8335_sff1_x4 1 1872 0 10050 1582 sff1_x4
xsubckt_7461_a2_x2 0 9235 1 7998 8138 a2_x2
xsubckt_6913_ao22_x2 0 8384 1 8385 8386 708 ao22_x2
xsubckt_6667_mx2_x2 0 1981 1 710 1982 1983 mx2_x2
xsubckt_6665_mx2_x2 0 1983 1 712 1081 1049 mx2_x2
xsubckt_6337_a2_x2 0 9398 1 2304 2346 a2_x2
xsubckt_6276_mx2_x2 0 2363 1 710 1475 1315 mx2_x2
xsubckt_5133_ao22_x2 0 3370 1 7101 3375 3371 ao22_x2
xsubckt_4881_a3_x2 1 3574 0 3584 3595 1758 a3_x2
xsubckt_3757_a3_x2 1 4221 0 4222 4223 4225 a3_x2
xsubckt_3531_a2_x2 0 4444 1 705 7452 a2_x2
xsubckt_3446_nand3_x0 1 0 4527 4528 5595 5608 nand3_x0
xsubckt_3360_nand2_x0 1 0 4612 705 1598 nand2_x0
xsubckt_2602_a2_x2 0 5356 1 5357 7179 a2_x2
xsubckt_1069_a2_x2 0 6754 1 696 71 a2_x2
xsubckt_894_mx2_x2 0 6921 1 229 403 385 mx2_x2
xsubckt_888_o2_x2 0 6927 1 674 49 o2_x2
xsubckt_1538_a2_x2 0 6303 1 7238 200 a2_x2
xsubckt_1828_mx2_x2 0 6023 1 574 6024 6241 mx2_x2
xsubckt_9666_sff1_x4 1 1872 0 8810 820 sff1_x4
xsubckt_9143_sff1_x4 1 1872 0 9315 1140 sff1_x4
xsubckt_6866_a2_x2 0 8430 1 8431 8437 a2_x2
xsubckt_6278_mx2_x2 0 2361 1 712 2362 2363 mx2_x2
xsubckt_5917_a2_x2 0 2714 1 2715 2718 a2_x2
xsubckt_5743_mx2_x2 0 9440 1 2856 449 486 mx2_x2
xsubckt_5741_mx2_x2 0 9442 1 2856 451 488 mx2_x2
xsubckt_5663_a2_x2 0 9451 1 2925 2926 a2_x2
xsubckt_5488_a2_x2 0 3052 1 3055 1866 a2_x2
xsubckt_5129_ao22_x2 0 3374 1 644 3522 7168 ao22_x2
xsubckt_4601_mx3_x2 1 0 9672 3768 3896 1104 3799 3801 mx3_x2
xsubckt_3865_a2_x2 0 10059 1 4116 4166 a2_x2
xsubckt_3180_nand2_x0 1 0 4788 7152 7268 nand2_x0
xsubckt_3134_oa22_x2 0 4834 1 4943 4883 4884 oa22_x2
xsubckt_2917_nand2_x0 1 0 5047 228 700 nand2_x0
xsubckt_2916_a2_x2 0 5048 1 228 700 a2_x2
xsubckt_1558_a2_x2 0 6283 1 434 218 a2_x2
xsubckt_1682_nand3_x0 1 0 6159 6390 7232 211 nand3_x0
xsubckt_9500_sff1_x4 1 1872 0 8966 1167 sff1_x4
xsubckt_8766_sff1_x4 1 1872 0 9627 1805 sff1_x4
xsubckt_6821_ao22_x2 0 8474 1 712 8475 7613 ao22_x2
xsubckt_5749_mx2_x2 0 9434 1 2856 473 510 mx2_x2
xsubckt_5747_mx2_x2 0 9436 1 2856 475 512 mx2_x2
xsubckt_5745_mx2_x2 0 9438 1 2856 477 514 mx2_x2
xsubckt_4664_ao22_x2 0 3743 1 1751 3748 40 ao22_x2
xsubckt_4038_o2_x2 0 3946 1 3947 706 o2_x2
xsubckt_3050_o2_x2 0 4916 1 4917 4919 o2_x2
xsubckt_40_inv_x0 1 0 128 7751 inv_x0
xsubckt_1857_oa22_x2 0 5997 1 196 226 574 oa22_x2
xsubckt_2234_oa22_x2 0 5717 1 5719 5731 7613 oa22_x2
xsubckt_9574_sff1_x4 1 1872 0 8899 924 sff1_x4
xsubckt_9139_sff1_x4 1 1872 0 9319 1144 sff1_x4
xsubckt_9051_sff1_x4 1 1872 0 9375 1319 sff1_x4
xsubckt_8600_sff1_x4 1 1872 0 9793 1453 sff1_x4
xsubckt_8131_mx3_x2 1 0 8696 7804 3896 1699 3850 3852 mx3_x2
xsubckt_7308_nand2_x0 1 0 9292 8092 8093 nand2_x0
xsubckt_4565_mx3_x2 1 0 9705 3771 3896 1426 3802 3804 mx3_x2
xsubckt_4563_mx3_x2 1 0 9707 3771 3896 1428 3808 3810 mx3_x2
xsubckt_4561_mx3_x2 1 0 9709 3771 3896 1430 3814 3816 mx3_x2
xsubckt_42_inv_x0 1 0 53 7749 inv_x0
xsubckt_44_inv_x0 1 0 56 7747 inv_x0
xsubckt_46_inv_x0 1 0 58 7745 inv_x0
xsubckt_1855_nand2_x0 1 0 1932 5999 6003 nand2_x0
xsubckt_2435_o2_x2 0 5520 1 5521 7218 o2_x2
xsubckt_8674_sff1_x4 1 1872 0 9719 1441 sff1_x4
xsubckt_8137_mx3_x2 1 0 8690 7804 3896 1693 3832 3834 mx3_x2
xsubckt_8135_mx3_x2 1 0 8692 7804 3896 1695 3838 3840 mx3_x2
xsubckt_8133_mx3_x2 1 0 8694 7804 3896 1697 3844 3846 mx3_x2
xsubckt_6679_o2_x2 0 1969 1 729 710 o2_x2
xsubckt_6336_nand2_x0 1 0 2304 2305 2307 nand2_x0
xsubckt_5945_o2_x2 0 2687 1 2688 711 o2_x2
xsubckt_5523_nor3_x0 1 0 9489 3027 3028 7702 nor3_x0
xsubckt_4567_mx3_x2 1 0 9703 3771 3896 1423 3797 3798 mx3_x2
xsubckt_4438_mx2_x2 0 9826 1 3776 3882 1006 mx2_x2
xsubckt_4436_mx2_x2 0 9828 1 3776 3890 1020 mx2_x2
xsubckt_4434_mx2_x2 0 9830 1 3776 3894 1032 mx2_x2
xsubckt_4047_mx2_x2 0 3937 1 705 720 1584 mx2_x2
xsubckt_4045_mx2_x2 0 3939 1 705 1680 1552 mx2_x2
xsubckt_2690_o2_x2 0 5269 1 5270 5284 o2_x2
xsubckt_48_inv_x0 1 0 60 7743 inv_x0
xsubckt_1546_o2_x2 0 6295 1 418 202 o2_x2
xsubckt_9482_sff1_x4 1 1872 0 8984 1187 sff1_x4
xsubckt_9047_sff1_x4 1 1872 0 9379 518 sff1_x4
xsubckt_8139_mx3_x2 1 0 8688 7804 3896 1690 3826 3828 mx3_x2
xsubckt_7211_mx3_x2 1 0 9314 8158 3896 1139 3805 3807 mx3_x2
xsubckt_5269_oa22_x2 0 3245 1 3247 3248 7690 oa22_x2
xsubckt_4049_mx2_x2 0 3935 1 707 3936 3937 mx2_x2
xsubckt_3512_nand2_x0 1 0 4463 705 954 nand2_x0
xsubckt_3250_mx3_x2 1 0 4720 707 705 4721 1536 1664 mx3_x2
xsubckt_3121_mx2_x2 0 4846 1 706 4847 4849 mx2_x2
xsubckt_2467_nand2_x0 1 0 5488 701 229 nand2_x0
xsubckt_1006_ao22_x2 0 6814 1 6817 6842 1740 ao22_x2
xsubckt_2050_oa22_x2 0 1914 1 5825 5824 5821 oa22_x2
xsubckt_9404_sff1_x4 1 1872 0 9062 1383 sff1_x4
xsubckt_8582_sff1_x4 1 1872 0 9811 1021 sff1_x4
xsubckt_8504_sff1_x4 1 1872 0 9889 973 sff1_x4
xsubckt_8099_mx3_x2 1 0 8758 7806 3896 769 3844 3846 mx3_x2
xsubckt_8097_mx3_x2 1 0 8760 7806 3896 771 3850 3852 mx3_x2
xsubckt_8095_mx3_x2 1 0 8762 7806 3897 773 3856 3857 mx3_x2
xsubckt_7213_mx3_x2 1 0 9312 8158 3896 1136 3799 3801 mx3_x2
xsubckt_5138_nxr2_x1 3366 1 0 3373 3519 nxr2_x1
xsubckt_3992_mx3_x2 1 0 3991 703 706 3992 3999 4001 mx3_x2
xsubckt_3470_mx2_x2 0 4504 1 707 4505 4506 mx2_x2
xsubckt_3256_mx3_x2 1 0 4714 707 705 4715 960 1120 mx3_x2
xsubckt_2965_nxr2_x1 5000 1 0 227 699 nxr2_x1
xsubckt_2352_nor4_x0 1 0 5602 1739 1741 1738 1737 nor4_x0
xsubckt_9835_sff1_x4 1 1872 0 8641 1230 sff1_x4
xsubckt_9478_sff1_x4 1 1872 0 8988 1161 sff1_x4
xsubckt_9390_sff1_x4 1 1872 0 9071 360 sff1_x4
xsubckt_8578_sff1_x4 1 1872 0 9815 1025 sff1_x4
xsubckt_7957_mx3_x2 1 0 8892 7814 3897 905 3863 3864 mx3_x2
xsubckt_7955_mx3_x2 1 0 8894 7814 3897 907 3871 3872 mx3_x2
xsubckt_7171_mx3_x2 1 0 9345 8167 3896 1295 3797 3798 mx3_x2
xsubckt_6110_ao22_x2 0 2525 1 7625 937 2526 ao22_x2
xsubckt_5613_nand3_x0 1 0 2961 2967 1829 1830 nand3_x0
xsubckt_5184_nand2_x0 1 0 9531 3324 3334 nand2_x0
xsubckt_5011_oa22_x2 0 9551 1 7168 3477 3479 oa22_x2
xsubckt_3474_mx2_x2 0 4500 1 706 4501 4504 mx2_x2
xsubckt_3472_mx2_x2 0 4502 1 7217 7465 7469 mx2_x2
xsubckt_2768_ao22_x2 0 5193 1 5194 5196 703 ao22_x2
xsubckt_2540_nand2_x0 1 0 5416 7153 7687 nand2_x0
xsubckt_1137_nand2_x0 1 0 6689 6691 6709 nand2_x0
xsubckt_631_nor3_x0 1 0 7161 484 482 483 nor3_x0
xsubckt_321_inv_x0 1 0 1053 7470 inv_x0
xsubckt_323_inv_x0 1 0 1371 7468 inv_x0
xsubckt_9386_sff1_x4 1 1872 0 9075 364 sff1_x4
xsubckt_9312_sff1_x4 1 1872 0 9149 1350 sff1_x4
xsubckt_8935_sff1_x4 1 1872 0 9458 1822 sff1_x4
xsubckt_8490_sff1_x4 1 1872 0 9903 1528 sff1_x4
xsubckt_8412_sff1_x4 1 1872 0 9981 873 sff1_x4
xsubckt_7959_mx3_x2 1 0 8890 7814 3897 933 3856 3857 mx3_x2
xsubckt_7780_mx2_x2 0 9057 1 7825 3874 1356 mx2_x2
xsubckt_7046_mx2_x2 0 8254 1 710 1488 1328 mx2_x2
xsubckt_6900_mx2_x2 0 8397 1 712 1684 1652 mx2_x2
xsubckt_6342_oa22_x2 0 2299 1 1569 710 712 oa22_x2
xsubckt_5733_ao22_x2 0 2859 1 481 7160 7159 ao22_x2
xsubckt_5433_nand3_x0 1 0 3093 3103 3109 3112 nand3_x0
xsubckt_5427_nor3_x0 1 0 3098 3127 3457 3460 nor3_x0
xsubckt_5305_a4_x2 0 3212 1 3252 3480 3483 3486 a4_x2
xsubckt_3478_mx2_x2 0 4496 1 705 1147 987 mx2_x2
xsubckt_2943_mx2_x2 0 5021 1 705 774 1638 mx2_x2
xsubckt_2941_mx2_x2 0 5023 1 705 1702 1574 mx2_x2
xsubckt_953_a2_x2 0 6865 1 671 46 a2_x2
xsubckt_706_nand2_x0 1 0 7095 7096 7194 nand2_x0
xsubckt_281_inv_x0 1 0 899 7510 inv_x0
xsubckt_325_inv_x0 1 0 923 7466 inv_x0
xsubckt_327_inv_x0 1 0 859 7464 inv_x0
xsubckt_329_inv_x0 1 0 795 7462 inv_x0
xsubckt_2360_nand2_x0 1 0 5594 5596 5607 nand2_x0
xsubckt_9743_sff1_x4 1 1872 0 8733 1706 sff1_x4
xsubckt_9308_sff1_x4 1 1872 0 9153 1324 sff1_x4
xsubckt_9220_sff1_x4 1 1872 0 9239 530 sff1_x4
xsubckt_8486_sff1_x4 1 1872 0 9907 1533 sff1_x4
xsubckt_6906_mx2_x2 0 8391 1 7625 7396 7398 mx2_x2
xsubckt_6904_mx2_x2 0 8393 1 710 8394 8395 mx2_x2
xsubckt_6902_mx2_x2 0 8395 1 712 1620 1588 mx2_x2
xsubckt_6122_mx2_x2 0 2514 1 710 1158 998 mx2_x2
xsubckt_5442_oa22_x2 0 9512 1 3085 3086 3094 oa22_x2
xsubckt_5007_oa22_x2 0 9552 1 7168 3480 3482 oa22_x2
xsubckt_3859_nand2_x0 1 0 4121 7152 7256 nand2_x0
xsubckt_3293_xr2_x1 4678 0 1 221 693 xr2_x1
xsubckt_2977_nand2_x0 1 0 4988 4989 7219 nand2_x0
xsubckt_2945_mx2_x2 0 5019 1 706 5020 5022 mx2_x2
xsubckt_2554_mx2_x2 0 5403 1 7219 5404 5405 mx2_x2
xsubckt_2552_mx2_x2 0 5405 1 705 1489 1329 mx2_x2
xsubckt_674_inv_x0 1 0 7122 9638 inv_x0
xsubckt_283_inv_x0 1 0 835 7508 inv_x0
xsubckt_285_inv_x0 1 0 1603 7506 inv_x0
xsubckt_287_inv_x0 1 0 1507 7504 inv_x0
xsubckt_1210_nand2_x0 1 0 6620 6622 6643 nand2_x0
xsubckt_1917_nand2_x0 1 0 5942 6114 6340 nand2_x0
xsubckt_2002_nand2_x0 1 0 1918 5865 5869 nand2_x0
xsubckt_2209_mx2_x2 0 5742 1 710 1148 988 mx2_x2
xsubckt_9294_sff1_x4 1 1872 0 9167 672 sff1_x4
xsubckt_8843_sff1_x4 1 1872 0 9550 60 sff1_x4
xsubckt_8408_sff1_x4 1 1872 0 9985 877 sff1_x4
xsubckt_8320_sff1_x4 1 1872 0 10065 217 sff1_x4
xsubckt_6862_mx2_x2 0 8434 1 710 757 1621 mx2_x2
xsubckt_6860_mx2_x2 0 8436 1 710 1685 1557 mx2_x2
xsubckt_6338_oa22_x2 0 2303 1 40 1741 193 oa22_x2
xsubckt_6250_oa22_x2 0 2389 1 40 1741 195 oa22_x2
xsubckt_6128_mx2_x2 0 2508 1 710 934 806 mx2_x2
xsubckt_6124_mx2_x2 0 2512 1 710 1446 1286 mx2_x2
xsubckt_4143_a2_x2 0 3854 1 3858 73 a2_x2
xsubckt_3810_a3_x2 1 4169 0 4170 5595 5608 a3_x2
xsubckt_3401_nand3_x0 1 0 4571 4572 5595 5608 nand3_x0
xsubckt_3186_a3_x2 1 4782 0 4783 5595 5608 a3_x2
xsubckt_2558_mx2_x2 0 5399 1 705 1361 849 mx2_x2
xsubckt_2500_a2_x2 0 5456 1 5457 7216 a2_x2
xsubckt_289_inv_x0 1 0 1347 7502 inv_x0
xsubckt_2311_oa22_x2 0 5642 1 5643 710 7631 oa22_x2
xsubckt_9739_sff1_x4 1 1872 0 8737 1710 sff1_x4
xsubckt_9651_sff1_x4 1 1872 0 8825 836 sff1_x4
xsubckt_9216_sff1_x4 1 1872 0 9243 533 sff1_x4
xsubckt_8394_sff1_x4 1 1872 0 9991 1551 sff1_x4
xsubckt_7613_a2_x2 0 7904 1 651 600 a2_x2
xsubckt_7438_a2_x2 0 8012 1 8013 8014 a2_x2
xsubckt_6972_ao22_x2 0 8326 1 710 8329 8327 ao22_x2
xsubckt_6864_mx2_x2 0 8432 1 711 8433 8435 mx2_x2
xsubckt_6704_a2_x2 0 9390 1 1945 1987 a2_x2
xsubckt_6082_mx2_x2 0 2553 1 7625 7540 7542 mx2_x2
xsubckt_5694_nand2_x0 1 0 2897 2898 2901 nand2_x0
xsubckt_5521_a2_x2 0 3028 1 3031 1856 a2_x2
xsubckt_5385_nxr2_x1 3137 1 0 3153 3465 nxr2_x1
xsubckt_5350_oa22_x2 0 3170 1 3475 3478 7672 oa22_x2
xsubckt_5346_a2_x2 0 3174 1 3189 3200 a2_x2
xsubckt_3841_ao22_x2 0 4139 1 4140 4151 706 ao22_x2
xsubckt_1182_a2_x2 0 6646 1 219 1739 a2_x2
xsubckt_1436_a2_x2 0 6405 1 183 212 a2_x2
xsubckt_1631_a2_x2 0 6210 1 6211 6214 a2_x2
xsubckt_1881_nxr2_x1 5975 1 0 5976 6325 nxr2_x1
xsubckt_8839_sff1_x4 1 1872 0 9554 64 sff1_x4
xsubckt_8751_sff1_x4 1 1872 0 9642 1267 sff1_x4
xsubckt_8316_sff1_x4 1 1872 0 10069 222 sff1_x4
xsubckt_7531_nand2_x0 1 0 9195 7968 7969 nand2_x0
xsubckt_7458_a2_x2 0 7999 1 8014 8149 a2_x2
xsubckt_6445_ao22_x2 0 2198 1 2199 2207 711 ao22_x2
xsubckt_6308_nand2_x0 1 0 2332 2333 712 nand2_x0
xsubckt_6088_ao22_x2 0 2547 1 711 2559 708 ao22_x2
xsubckt_5944_mx2_x2 0 2688 1 710 2689 2690 mx2_x2
xsubckt_5942_mx2_x2 0 2690 1 712 1068 1036 mx2_x2
xsubckt_5940_mx2_x2 0 2692 1 712 1132 1100 mx2_x2
xsubckt_5600_nor3_x0 1 0 9468 2971 2972 7702 nor3_x0
xsubckt_4737_ao22_x2 0 3684 1 1794 3685 40 ao22_x2
xsubckt_4692_a2_x2 0 3722 1 1803 1802 a2_x2
xsubckt_4411_mx3_x2 1 0 9851 3779 3897 1509 3856 3857 mx3_x2
xsubckt_3752_nand2_x0 1 0 4226 7153 7263 nand2_x0
xsubckt_3743_a2_x2 0 4235 1 4236 706 a2_x2
xsubckt_2619_a2_x2 0 5339 1 5340 5343 a2_x2
xsubckt_863_nand3_x0 1 0 6950 6951 6952 6953 nand3_x0
xsubckt_1647_nand2_x0 1 0 6194 7222 222 nand2_x0
xsubckt_1983_mx2_x2 0 5882 1 574 5883 5886 mx2_x2
xsubckt_9647_sff1_x4 1 1872 0 8829 810 sff1_x4
xsubckt_9124_sff1_x4 1 1872 0 9334 1130 sff1_x4
xsubckt_8747_sff1_x4 1 1872 0 9646 1271 sff1_x4
xsubckt_7553_o3_x2 0 7950 1 7952 7955 7958 o3_x2
xsubckt_5948_mx2_x2 0 2684 1 710 1676 1548 mx2_x2
xsubckt_5781_oa22_x2 0 2842 1 7142 7065 7134 oa22_x2
xsubckt_4417_mx3_x2 1 0 9845 3779 3896 1503 3838 3840 mx3_x2
xsubckt_4415_mx3_x2 1 0 9847 3779 3896 1505 3844 3846 mx3_x2
xsubckt_4413_mx3_x2 1 0 9849 3779 3896 1507 3850 3852 mx3_x2
xsubckt_3662_nand2_x0 1 0 4315 4316 7219 nand2_x0
xsubckt_3550_oa22_x2 0 4425 1 1018 706 705 oa22_x2
xsubckt_3507_nxr2_x1 4468 1 0 4471 4472 nxr2_x1
xsubckt_2894_a2_x2 0 5069 1 5070 7218 a2_x2
xsubckt_2650_oa22_x2 0 5309 1 5361 5358 5360 oa22_x2
xsubckt_981_oa22_x2 0 6838 1 6889 6863 6865 oa22_x2
xsubckt_1393_oa22_x2 0 6446 1 6719 6455 6447 oa22_x2
xsubckt_1455_xr2_x1 6386 0 1 182 211 xr2_x1
xsubckt_1810_nand2_x0 1 0 6039 6112 6249 nand2_x0
xsubckt_9198_sff1_x4 1 1872 0 9260 667 sff1_x4
xsubckt_7593_o3_x2 0 7920 1 7921 7952 7955 o3_x2
xsubckt_7573_o3_x2 0 7935 1 7936 7952 7955 o3_x2
xsubckt_7351_nand2_x0 1 0 9282 8059 8061 nand2_x0
xsubckt_7172_o2_x2 0 8165 1 1737 1742 o2_x2
xsubckt_6876_ao22_x2 0 8420 1 8421 8422 708 ao22_x2
xsubckt_6555_nand3_x0 1 0 2090 2091 2098 7613 nand3_x0
xsubckt_6489_o3_x2 0 2155 1 2156 2157 7620 o3_x2
xsubckt_6263_o2_x2 0 2376 1 1667 710 o2_x2
xsubckt_5902_ao22_x2 0 2729 1 5745 5747 7082 ao22_x2
xsubckt_5254_oa22_x2 0 3259 1 7680 3493 7167 oa22_x2
xsubckt_5159_o2_x2 0 9533 1 3347 3357 o2_x2
xsubckt_4419_mx3_x2 1 0 9843 3779 3896 1501 3832 3834 mx3_x2
xsubckt_4373_mx3_x2 1 0 9886 3782 3897 970 3867 3868 mx3_x2
xsubckt_4364_nand2_x0 1 0 3781 3783 3796 nand2_x0
xsubckt_4191_o2_x2 0 3818 1 3821 7743 o2_x2
xsubckt_3911_nand3_x0 1 0 4070 4071 5595 5608 nand3_x0
xsubckt_3800_nor3_x0 1 0 4179 4180 4186 704 nor3_x0
xsubckt_1109_nand2_x0 1 0 6715 588 1800 nand2_x0
xsubckt_1424_o2_x2 0 6417 1 180 209 o2_x2
xsubckt_1894_nand3_x0 1 0 5963 5964 5965 5966 nand3_x0
xsubckt_9555_sff1_x4 1 1872 0 8918 1217 sff1_x4
xsubckt_9032_sff1_x4 1 1872 0 9394 190 sff1_x4
xsubckt_8655_sff1_x4 1 1872 0 9738 1075 sff1_x4
xsubckt_6752_o2_x2 0 8541 1 8542 7134 o2_x2
xsubckt_6201_nand2_x0 1 0 2436 2437 2442 nand2_x0
xsubckt_5976_ao22_x2 0 2656 1 534 532 674 ao22_x2
xsubckt_5673_nand3_x0 1 0 2918 7105 7154 1739 nand3_x0
xsubckt_5453_ao22_x2 0 3077 1 3082 1848 40 ao22_x2
xsubckt_4379_mx3_x2 1 0 9880 3782 3896 994 3847 3849 mx3_x2
xsubckt_4377_mx3_x2 1 0 9882 3782 3896 996 3853 3855 mx3_x2
xsubckt_4375_mx3_x2 1 0 9884 3782 3897 998 3859 3860 mx3_x2
xsubckt_3731_o2_x2 0 4247 1 705 1015 o2_x2
xsubckt_3596_o2_x2 0 4380 1 4381 707 o2_x2
xsubckt_2845_ao22_x2 0 5117 1 706 5118 5586 ao22_x2
xsubckt_2822_o2_x2 0 5140 1 5141 7215 o2_x2
xsubckt_2667_o2_x2 0 5292 1 705 1389 o2_x2
xsubckt_946_nand2_x0 1 0 6871 587 1772 nand2_x0
xsubckt_1484_o2_x2 0 6357 1 191 221 o2_x2
xsubckt_1540_nand2_x0 1 0 6301 6302 6309 nand2_x0
xsubckt_1588_ao22_x2 0 6253 1 6269 6267 6254 ao22_x2
xsubckt_9463_sff1_x4 1 1872 0 9003 1397 sff1_x4
xsubckt_9028_sff1_x4 1 1872 0 9398 194 sff1_x4
xsubckt_7803_mx3_x2 1 0 9034 7826 3896 1362 3802 3804 mx3_x2
xsubckt_7801_mx3_x2 1 0 9036 7826 3896 1364 3808 3810 mx3_x2
xsubckt_7606_ao22_x2 0 7910 1 607 594 367 ao22_x2
xsubckt_7081_nand2_x0 1 0 8220 8221 8224 nand2_x0
xsubckt_4986_mx2_x2 0 3495 1 5753 3840 131 mx2_x2
xsubckt_4982_mx2_x2 0 3498 1 5753 3843 132 mx2_x2
xsubckt_4910_ao22_x2 0 3552 1 1749 3554 40 ao22_x2
xsubckt_3320_mx2_x2 0 4651 1 705 1471 1311 mx2_x2
xsubckt_3124_nand2_x0 1 0 4843 7153 7275 nand2_x0
xsubckt_1170_nxr2_x1 6658 1 0 691 66 nxr2_x1
xsubckt_9820_sff1_x4 1 1872 0 8656 1658 sff1_x4
xsubckt_8563_sff1_x4 1 1872 0 9830 1032 sff1_x4
xsubckt_7809_mx3_x2 1 0 9030 7684 7675 7823 2741 648 mx3_x2
xsubckt_7807_mx3_x2 1 0 9031 7684 7675 7824 2787 649 mx3_x2
xsubckt_7805_mx3_x2 1 0 9032 7826 3896 1359 3797 3798 mx3_x2
xsubckt_7698_nand2_x0 1 0 7834 7835 7838 nand2_x0
xsubckt_7592_ao22_x2 0 7921 1 607 594 363 ao22_x2
xsubckt_5884_ao22_x2 0 2743 1 2744 2750 708 ao22_x2
xsubckt_5578_nor3_x0 1 0 9474 2987 2988 7702 nor3_x0
xsubckt_5490_nor3_x0 1 0 9498 3051 3052 7702 nor3_x0
xsubckt_3637_nand4_x0 1 0 4339 5604 532 7689 62 nand4_x0
xsubckt_3326_mx2_x2 0 4645 1 703 4646 4649 mx2_x2
xsubckt_3324_mx2_x2 0 4647 1 705 1375 863 mx2_x2
xsubckt_3322_mx2_x2 0 4649 1 707 4650 4651 mx2_x2
xsubckt_885_oa22_x2 0 6929 1 1737 6937 6931 oa22_x2
xsubckt_662_nand4_x0 1 0 7133 7135 7138 7144 7150 nand4_x0
xsubckt_9894_sff1_x4 1 1872 0 8582 1615 sff1_x4
xsubckt_9459_sff1_x4 1 1872 0 9007 1401 sff1_x4
xsubckt_9371_sff1_x4 1 1872 0 9090 350 sff1_x4
xsubckt_8920_sff1_x4 1 1872 0 9473 1839 sff1_x4
xsubckt_7765_mx3_x2 1 0 9102 7828 3896 1046 3814 3816 mx3_x2
xsubckt_7763_mx3_x2 1 0 9104 7828 3896 1048 3820 3822 mx3_x2
xsubckt_7761_mx3_x2 1 0 9106 7828 3896 1050 3826 3828 mx3_x2
xsubckt_6850_oa22_x2 0 8446 1 40 1741 182 oa22_x2
xsubckt_5135_nand3_x0 1 0 3369 40 109 7780 nand3_x0
xsubckt_5070_oa22_x2 0 3428 1 7102 3433 3429 oa22_x2
xsubckt_4906_ao22_x2 0 3555 1 1750 3557 40 ao22_x2
xsubckt_4219_nxr2_x1 3797 1 0 3800 7750 nxr2_x1
xsubckt_3671_mx2_x2 0 4306 1 706 1048 952 mx2_x2
xsubckt_2769_nand2_x0 1 0 5192 5193 5198 nand2_x0
xsubckt_643_o4_x2 0 7152 1 577 575 576 578 o4_x2
xsubckt_131_inv_x0 1 0 667 7660 inv_x0
xsubckt_520_inv_x0 1 0 222 7271 inv_x0
xsubckt_522_inv_x0 1 0 221 7269 inv_x0
xsubckt_1887_nand2_x0 1 0 5970 6207 6328 nand2_x0
xsubckt_9816_sff1_x4 1 1872 0 8660 1663 sff1_x4
xsubckt_8994_sff1_x4 1 1872 0 9431 507 sff1_x4
xsubckt_8559_sff1_x4 1 1872 0 9834 1491 sff1_x4
xsubckt_8471_sff1_x4 1 1872 0 9922 1518 sff1_x4
xsubckt_7769_mx3_x2 1 0 9098 7828 3896 1042 3802 3804 mx3_x2
xsubckt_7767_mx3_x2 1 0 9100 7828 3896 1044 3808 3810 mx3_x2
xsubckt_7588_ao22_x2 0 7924 1 607 594 362 ao22_x2
xsubckt_7065_ao22_x2 0 8235 1 8240 8238 8236 ao22_x2
xsubckt_6841_mx3_x2 1 0 8454 712 710 8455 1590 726 mx3_x2
xsubckt_5714_ao22_x2 0 2877 1 7219 2878 7216 ao22_x2
xsubckt_5562_nand4_x0 1 0 2998 3007 1846 1844 1845 nand4_x0
xsubckt_5515_oa22_x2 0 3032 1 1860 3039 1858 oa22_x2
xsubckt_4892_ao22_x2 0 3565 1 3567 3631 7721 ao22_x2
xsubckt_3677_mx2_x2 0 4300 1 705 1720 888 mx2_x2
xsubckt_2884_mx3_x2 1 0 5079 707 705 5080 1289 1449 mx3_x2
xsubckt_2842_nand2_x0 1 0 5120 5121 704 nand2_x0
xsubckt_2462_oa22_x2 0 5493 1 5494 5497 707 oa22_x2
xsubckt_137_inv_x0 1 0 662 7654 inv_x0
xsubckt_135_inv_x0 1 0 670 7656 inv_x0
xsubckt_133_inv_x0 1 0 373 7658 inv_x0
xsubckt_480_inv_x0 1 0 90 7311 inv_x0
xsubckt_524_inv_x0 1 0 219 7267 inv_x0
xsubckt_526_inv_x0 1 0 216 7265 inv_x0
xsubckt_528_inv_x0 1 0 214 7263 inv_x0
xsubckt_1529_nand2_x0 1 0 6312 198 228 nand2_x0
xsubckt_1619_nand2_x0 1 0 6222 195 225 nand2_x0
xsubckt_1797_nand2_x0 1 0 6051 6052 6297 nand2_x0
xsubckt_2148_mx3_x2 1 0 467 7162 5754 218 96 128 mx3_x2
xsubckt_2408_mx2_x2 0 5546 1 705 1704 1576 mx2_x2
xsubckt_9367_sff1_x4 1 1872 0 9094 376 sff1_x4
xsubckt_8916_sff1_x4 1 1872 0 9477 1843 sff1_x4
xsubckt_7987_mx2_x2 0 8864 1 7811 3878 845 mx2_x2
xsubckt_7985_mx2_x2 0 8866 1 7811 3886 849 mx2_x2
xsubckt_7983_mx2_x2 0 8868 1 7811 3892 871 mx2_x2
xsubckt_7677_nand3_x0 1 0 7851 7853 7679 644 nand3_x0
xsubckt_7228_a3_x2 1 8150 0 9090 7132 7194 a3_x2
xsubckt_6843_mx3_x2 1 0 8452 7620 7613 8453 8458 8461 mx3_x2
xsubckt_6321_mx2_x2 0 2319 1 710 1506 1346 mx2_x2
xsubckt_6107_mx3_x2 1 0 2528 712 710 2529 7531 7533 mx3_x2
xsubckt_5517_a4_x2 0 3031 1 3039 1857 1858 1860 a4_x2
xsubckt_5311_a3_x2 1 3207 0 40 124 7780 a3_x2
xsubckt_3277_nor2_x0 1 0 4693 4694 7215 nor2_x0
xsubckt_3034_ao22_x2 0 4932 1 4933 4935 4936 ao22_x2
xsubckt_3013_nand3_x0 1 0 4952 4953 5116 5699 nand3_x0
xsubckt_2458_oa22_x2 0 5497 1 1223 7218 5498 oa22_x2
xsubckt_139_inv_x0 1 0 374 7652 inv_x0
xsubckt_482_inv_x0 1 0 89 7309 inv_x0
xsubckt_484_inv_x0 1 0 88 7307 inv_x0
xsubckt_486_inv_x0 1 0 87 7305 inv_x0
xsubckt_9724_sff1_x4 1 1872 0 8752 762 sff1_x4
xsubckt_9201_sff1_x4 1 1872 0 9257 658 sff1_x4
xsubckt_8824_sff1_x4 1 1872 0 9569 50 sff1_x4
xsubckt_8467_sff1_x4 1 1872 0 9926 1544 sff1_x4
xsubckt_7288_a3_x2 1 8105 0 7658 372 7661 a3_x2
xsubckt_6531_nand2_x0 1 0 2114 2115 2116 nand2_x0
xsubckt_6327_mx2_x2 0 2313 1 712 2314 2315 mx2_x2
xsubckt_6325_mx2_x2 0 2315 1 710 1410 1250 mx2_x2
xsubckt_6323_mx2_x2 0 2317 1 710 1730 898 mx2_x2
xsubckt_6319_oa22_x2 0 2321 1 2322 2337 7620 oa22_x2
xsubckt_4888_ao22_x2 0 3568 1 1756 3569 40 ao22_x2
xsubckt_4061_a2_x2 0 3923 1 705 7378 a2_x2
xsubckt_4021_a2_x2 0 10056 1 3963 4011 a2_x2
xsubckt_1040_a2_x2 0 6781 1 226 1739 a2_x2
xsubckt_488_inv_x0 1 0 86 7303 inv_x0
xsubckt_1602_nand2_x0 1 0 6239 6240 6310 nand2_x0
xsubckt_1715_a3_x2 1 6126 0 6127 6129 6331 a3_x2
xsubckt_1780_nand2_x0 1 0 6066 6112 6289 nand2_x0
xsubckt_1993_oa22_x2 0 5873 1 184 213 574 oa22_x2
xsubckt_2223_a2_x2 0 5728 1 5729 709 a2_x2
xsubckt_9798_sff1_x4 1 1872 0 8678 1679 sff1_x4
xsubckt_9275_sff1_x4 1 1872 0 9186 682 sff1_x4
xsubckt_8898_sff1_x4 1 1872 0 9495 1863 sff1_x4
xsubckt_8375_sff1_x4 1 1872 0 10010 1572 sff1_x4
xsubckt_8301_sff1_x4 1 1872 0 10084 229 sff1_x4
xsubckt_7356_a2_x2 0 8055 1 8060 8091 a2_x2
xsubckt_6283_mx2_x2 0 2356 1 712 2357 2358 mx2_x2
xsubckt_6281_mx2_x2 0 2358 1 710 1411 1251 mx2_x2
xsubckt_6231_oa22_x2 0 2407 1 2408 2421 7620 oa22_x2
xsubckt_5696_ao22_x2 0 2895 1 1231 7219 2896 ao22_x2
xsubckt_5645_a3_x2 1 2938 0 2943 1819 1820 a3_x2
xsubckt_5089_a2_x2 0 3411 1 3531 663 a2_x2
xsubckt_5010_mx2_x2 0 3477 1 5753 3822 124 mx2_x2
xsubckt_4756_a3_x2 1 3669 0 3671 3707 3711 a3_x2
xsubckt_3465_ao22_x2 0 4509 1 7219 4510 706 ao22_x2
xsubckt_2911_nand3_x0 1 0 5052 5053 5595 5608 nand3_x0
xsubckt_2482_nand2_x0 1 0 5474 707 1052 nand2_x0
xsubckt_1169_nand2_x0 1 0 6659 691 66 nand2_x0
xsubckt_822_ao22_x2 0 6989 1 6999 6998 6990 ao22_x2
xsubckt_1374_a2_x2 0 6464 1 208 1739 a2_x2
xsubckt_1608_a2_x2 0 6233 1 6234 6310 a2_x2
xsubckt_9632_sff1_x4 1 1872 0 8841 851 sff1_x4
xsubckt_8732_sff1_x4 1 1872 0 9661 1257 sff1_x4
xsubckt_7053_nand2_x0 1 0 8247 8248 8252 nand2_x0
xsubckt_6487_a2_x2 0 2157 1 2158 2164 a2_x2
xsubckt_6261_nand2_x0 1 0 2378 2379 7631 nand2_x0
xsubckt_5881_mx3_x2 1 0 2746 712 710 2747 967 1127 mx3_x2
xsubckt_5750_mx2_x2 0 9433 1 2856 472 509 mx2_x2
xsubckt_5618_ao22_x2 0 2957 1 2962 1828 40 ao22_x2
xsubckt_5530_ao22_x2 0 3021 1 3026 1854 40 ao22_x2
xsubckt_5201_nand2_x0 1 0 3308 3505 7660 nand2_x0
xsubckt_5014_mx2_x2 0 3474 1 5753 3819 123 mx2_x2
xsubckt_4759_nand4_x0 1 0 3666 3671 3707 3711 1790 nand4_x0
xsubckt_4187_o4_x2 0 3821 1 3830 7740 7741 7742 o4_x2
xsubckt_3681_a2_x2 0 4296 1 4297 7219 a2_x2
xsubckt_2958_a3_x2 1 5006 0 5007 5009 5010 a3_x2
xsubckt_2732_a2_x2 0 5228 1 5229 7217 a2_x2
xsubckt_1332_nand2_x0 1 0 6504 1816 589 nand2_x0
xsubckt_1422_nand2_x0 1 0 6419 6420 6426 nand2_x0
xsubckt_9628_sff1_x4 1 1872 0 8845 855 sff1_x4
xsubckt_9540_sff1_x4 1 1872 0 8933 1224 sff1_x4
xsubckt_9183_sff1_x4 1 1872 0 9275 609 sff1_x4
xsubckt_9105_sff1_x4 1 1872 0 1922 1890 sff1_x4
xsubckt_7431_o3_x2 0 8018 1 538 533 599 o3_x2
xsubckt_7302_nand3_x0 1 0 8096 538 7679 644 nand3_x0
xsubckt_6426_ao22_x2 0 2216 1 534 532 694 ao22_x2
xsubckt_6081_nand2_x0 1 0 2554 2555 2556 nand2_x0
xsubckt_5756_mx2_x2 0 9427 1 2856 465 502 mx2_x2
xsubckt_5754_mx2_x2 0 9429 1 2856 468 505 mx2_x2
xsubckt_5752_mx2_x2 0 9431 1 2856 470 507 mx2_x2
xsubckt_5598_a2_x2 0 2972 1 2975 1833 a2_x2
xsubckt_5375_nand3_x0 1 0 3147 40 120 7780 nand3_x0
xsubckt_5018_mx2_x2 0 3471 1 5753 3816 122 mx2_x2
xsubckt_4616_mx3_x2 1 0 9660 3765 3897 1286 3859 3860 mx3_x2
xsubckt_4614_mx3_x2 1 0 9662 3765 3897 1258 3867 3868 mx3_x2
xsubckt_3995_a2_x2 0 3988 1 3989 7217 a2_x2
xsubckt_3140_o2_x2 0 4828 1 4829 4830 o2_x2
xsubckt_2641_nand3_x0 1 0 5317 5318 5482 5699 nand3_x0
xsubckt_1300_oa22_x2 0 6534 1 6719 6543 6535 oa22_x2
xsubckt_1897_oa22_x2 0 5961 1 192 222 574 oa22_x2
xsubckt_1949_nand2_x0 1 0 5913 6116 6366 nand2_x0
xsubckt_2034_nand2_x0 1 0 5835 5836 6413 nand2_x0
xsubckt_9179_sff1_x4 1 1872 0 9279 572 sff1_x4
xsubckt_8728_sff1_x4 1 1872 0 9665 1261 sff1_x4
xsubckt_8640_sff1_x4 1 1872 0 9753 1091 sff1_x4
xsubckt_6181_o2_x2 0 2456 1 1669 710 o2_x2
xsubckt_5769_nor2_x0 1 0 2854 1743 1742 nor2_x0
xsubckt_5758_mx2_x2 0 9425 1 2856 463 500 mx2_x2
xsubckt_5285_nand3_x0 1 0 3231 40 126 7780 nand3_x0
xsubckt_4965_mx3_x2 1 0 3511 5754 518 7761 7336 7337 mx3_x2
xsubckt_4961_mx3_x2 1 0 3514 5754 518 7760 7338 7339 mx3_x2
xsubckt_4618_mx3_x2 1 0 9658 3765 3896 1284 3853 3855 mx3_x2
xsubckt_4181_mx3_x2 1 0 10033 3899 3896 1594 3826 3828 mx3_x2
xsubckt_3964_nand2_x0 1 0 4018 7153 7259 nand2_x0
xsubckt_3923_nxr2_x1 4059 1 0 4061 4062 nxr2_x1
xsubckt_3082_oa22_x2 0 4885 1 5595 5608 225 oa22_x2
xsubckt_1138_ao22_x2 0 6688 1 6689 6705 1740 ao22_x2
xsubckt_51_inv_x0 1 0 63 7740 inv_x0
xsubckt_53_inv_x0 1 0 66 7738 inv_x0
xsubckt_1362_o2_x2 0 6476 1 680 55 o2_x2
xsubckt_2298_nand3_x0 1 0 5655 5656 7105 1739 nand3_x0
xsubckt_9536_sff1_x4 1 1872 0 10102 1740 sff1_x4
xsubckt_9091_sff1_x4 1 1872 0 1907 1875 sff1_x4
xsubckt_9013_sff1_x4 1 1872 0 302 644 sff1_x4
xsubckt_8144_mx3_x2 1 0 8683 7804 3896 1685 3811 3813 mx3_x2
xsubckt_8142_mx3_x2 1 0 8685 7804 3896 1687 3817 3819 mx3_x2
xsubckt_8140_mx3_x2 1 0 8687 7804 3896 1689 3823 3825 mx3_x2
xsubckt_7476_nand4_x0 1 0 7985 7202 7697 40 481 nand4_x0
xsubckt_6709_o2_x2 0 1940 1 1112 710 o2_x2
xsubckt_6334_ao22_x2 0 2306 1 534 532 696 ao22_x2
xsubckt_4969_mx3_x2 1 0 3508 5754 518 7762 7334 7335 mx3_x2
xsubckt_4578_mx3_x2 1 0 9695 3768 3897 1099 3871 3872 mx3_x2
xsubckt_4399_nand4_x0 1 0 3778 3780 3901 3903 3906 nand4_x0
xsubckt_4185_mx3_x2 1 0 10032 3899 3896 1593 3823 3825 mx3_x2
xsubckt_4050_mx2_x2 0 3934 1 706 3935 3938 mx2_x2
xsubckt_3969_nor2_x0 1 0 4013 4014 4021 nor2_x0
xsubckt_3855_nor3_x0 1 0 4125 4126 4139 5585 nor3_x0
xsubckt_3305_mx3_x2 1 0 4666 707 705 4667 1535 1663 mx3_x2
xsubckt_2760_o2_x2 0 5201 1 5202 7180 o2_x2
xsubckt_2740_o2_x2 0 5220 1 5221 5223 o2_x2
xsubckt_2545_o2_x2 0 5411 1 5412 5413 o2_x2
xsubckt_985_nand3_x0 1 0 6834 6835 6837 1740 nand3_x0
xsubckt_59_inv_x0 1 0 73 7732 inv_x0
xsubckt_57_inv_x0 1 0 71 7734 inv_x0
xsubckt_55_inv_x0 1 0 68 7736 inv_x0
xsubckt_1282_oa22_x2 0 154 1 1740 6562 6552 oa22_x2
xsubckt_1510_nor4_x0 1 0 6331 6333 6358 6382 6407 nor4_x0
xsubckt_9087_sff1_x4 1 1872 0 1913 1881 sff1_x4
xsubckt_8636_sff1_x4 1 1872 0 9757 1065 sff1_x4
xsubckt_8148_mx3_x2 1 0 8679 7804 3896 1680 3799 3801 mx3_x2
xsubckt_8146_mx3_x2 1 0 8681 7804 3896 1683 3805 3807 mx3_x2
xsubckt_8017_mx2_x2 0 8836 1 7809 3892 839 mx2_x2
xsubckt_5511_nor2_x0 1 0 3035 3039 1860 nor2_x0
xsubckt_5104_nxr2_x1 3397 1 0 3398 3401 nxr2_x1
xsubckt_4189_mx3_x2 1 0 10031 3899 3896 1592 3820 3822 mx3_x2
xsubckt_4011_ao22_x2 0 3972 1 7216 3973 5586 ao22_x2
xsubckt_2839_o2_x2 0 5123 1 5124 704 o2_x2
xsubckt_1569_ao22_x2 0 6272 1 6274 6280 6281 ao22_x2
xsubckt_1679_nand2_x0 1 0 6162 6163 6165 nand2_x0
xsubckt_2303_ao22_x2 0 5650 1 1454 710 712 ao22_x2
xsubckt_9444_sff1_x4 1 1872 0 9022 1387 sff1_x4
xsubckt_9009_sff1_x4 1 1872 0 9416 484 sff1_x4
xsubckt_8019_mx2_x2 0 8834 1 7809 3886 817 mx2_x2
xsubckt_5621_nand2_x0 1 0 2955 2958 7270 nand2_x0
xsubckt_5178_nxr2_x1 3329 1 0 3330 3333 nxr2_x1
xsubckt_5090_nxr2_x1 3410 1 0 3532 663 nxr2_x1
xsubckt_4915_nand3_x0 1 0 3548 3554 1749 1748 nand3_x0
xsubckt_4204_nxr2_x1 3808 1 0 3812 7746 nxr2_x1
xsubckt_3694_nand2_x0 1 0 4283 4284 703 nand2_x0
xsubckt_3516_nand2_x0 1 0 4459 7217 1210 nand2_x0
xsubckt_2634_nand2_x0 1 0 5324 5351 7215 nand2_x0
xsubckt_1151_nxr2_x1 6676 1 0 692 67 nxr2_x1
xsubckt_1842_nand2_x0 1 0 6010 6112 6236 nand2_x0
xsubckt_2090_oa22_x2 0 5787 1 7685 308 7239 oa22_x2
xsubckt_9801_sff1_x4 1 1872 0 8675 1660 sff1_x4
xsubckt_8901_sff1_x4 1 1872 0 9492 1860 sff1_x4
xsubckt_8544_sff1_x4 1 1872 0 9849 1507 sff1_x4
xsubckt_7964_mx3_x2 1 0 8885 7814 3896 928 3841 3843 mx3_x2
xsubckt_7962_mx3_x2 1 0 8887 7814 3896 930 3847 3849 mx3_x2
xsubckt_7960_mx3_x2 1 0 8889 7814 3896 932 3853 3855 mx3_x2
xsubckt_7050_ao22_x2 0 8250 1 7625 1296 8251 ao22_x2
xsubckt_4825_nand3_x0 1 0 3616 3622 1774 1772 nand3_x0
xsubckt_3866_oa22_x2 0 4115 1 5595 5608 210 oa22_x2
xsubckt_3483_mx2_x2 0 4491 1 705 1691 1563 mx2_x2
xsubckt_3269_mx3_x2 1 0 4701 707 705 4702 1600 736 mx3_x2
xsubckt_808_a2_x2 0 7003 1 690 65 a2_x2
xsubckt_330_inv_x0 1 0 1531 7461 inv_x0
xsubckt_1662_nand2_x0 1 0 6179 7227 216 nand2_x0
xsubckt_1748_nand3_x0 1 0 6095 6096 6097 6098 nand3_x0
xsubckt_9875_sff1_x4 1 1872 0 8601 1636 sff1_x4
xsubckt_9352_sff1_x4 1 1872 0 9109 1054 sff1_x4
xsubckt_8975_sff1_x4 1 1872 0 150 87 sff1_x4
xsubckt_8452_sff1_x4 1 1872 0 9941 735 sff1_x4
xsubckt_7968_mx3_x2 1 0 8881 7814 3896 923 3829 3831 mx3_x2
xsubckt_7966_mx3_x2 1 0 8883 7814 3896 926 3835 3837 mx3_x2
xsubckt_6831_oa22_x2 0 8464 1 8465 8478 7628 oa22_x2
xsubckt_5098_nand2_x0 1 0 9538 3403 3413 nand2_x0
xsubckt_4674_oa22_x2 0 3736 1 3739 1745 1744 oa22_x2
xsubckt_3878_mx2_x2 0 4103 1 705 1652 1524 mx2_x2
xsubckt_3876_mx2_x2 0 4105 1 705 1012 820 mx2_x2
xsubckt_3487_mx2_x2 0 4487 1 706 4488 4490 mx2_x2
xsubckt_3485_mx2_x2 0 4489 1 705 763 1627 mx2_x2
xsubckt_3107_ao22_x2 0 4860 1 7219 4861 706 ao22_x2
xsubckt_3096_mx2_x2 0 4871 1 707 4872 4873 mx2_x2
xsubckt_3094_mx2_x2 0 4873 1 7217 7509 7513 mx2_x2
xsubckt_3092_mx2_x2 0 4875 1 7217 7508 7512 mx2_x2
xsubckt_2950_mx2_x2 0 5014 1 706 5015 5017 mx2_x2
xsubckt_2607_mx2_x2 0 5351 1 706 5352 5354 mx2_x2
xsubckt_2605_mx2_x2 0 5353 1 705 750 1614 mx2_x2
xsubckt_2603_mx2_x2 0 5355 1 705 1678 1550 mx2_x2
xsubckt_1079_nor3_x0 1 0 6744 6745 6746 6879 nor3_x0
xsubckt_868_a2_x2 0 6946 1 675 50 a2_x2
xsubckt_594_a2_x2 0 7197 1 7200 7203 a2_x2
xsubckt_332_inv_x0 1 0 1435 7459 inv_x0
xsubckt_334_inv_x0 1 0 1275 7457 inv_x0
xsubckt_336_inv_x0 1 0 858 7455 inv_x0
xsubckt_1504_nxr2_x1 6337 1 0 190 220 nxr2_x1
xsubckt_2008_oa22_x2 0 5859 1 5860 5861 6385 oa22_x2
xsubckt_9783_sff1_x4 1 1872 0 8693 1696 sff1_x4
xsubckt_9348_sff1_x4 1 1872 0 9113 1058 sff1_x4
xsubckt_7542_nand3_x0 1 0 7960 7168 7791 654 nand3_x0
xsubckt_7301_a3_x2 1 8097 0 538 7679 644 a3_x2
xsubckt_6827_oa22_x2 0 8468 1 7625 1430 8469 oa22_x2
xsubckt_6669_ao22_x2 0 1979 1 7628 1984 708 ao22_x2
xsubckt_6520_mx2_x2 0 2125 1 710 1405 1245 mx2_x2
xsubckt_5482_oa22_x2 0 3056 1 1869 3063 1868 oa22_x2
xsubckt_5437_nand3_x0 1 0 3089 3090 3091 600 nand3_x0
xsubckt_4701_a4_x2 0 3714 1 3715 3716 3722 3754 a4_x2
xsubckt_3973_ao22_x2 0 4010 1 4066 4061 4063 ao22_x2
xsubckt_3538_ao22_x2 0 4437 1 4438 4445 7215 ao22_x2
xsubckt_2561_mx2_x2 0 5396 1 7217 7589 7591 mx2_x2
xsubckt_1144_a3_x2 1 6682 0 6683 6684 6685 a3_x2
xsubckt_1020_oa22_x2 0 6800 1 1737 6809 6801 oa22_x2
xsubckt_290_inv_x0 1 0 1283 7501 inv_x0
xsubckt_292_inv_x0 1 0 1538 7499 inv_x0
xsubckt_294_inv_x0 1 0 1537 7497 inv_x0
xsubckt_338_inv_x0 1 0 794 7453 inv_x0
xsubckt_9705_sff1_x4 1 1872 0 8771 764 sff1_x4
xsubckt_9260_sff1_x4 1 1872 0 9201 317 sff1_x4
xsubckt_8883_sff1_x4 1 1872 0 9510 1870 sff1_x4
xsubckt_8448_sff1_x4 1 1872 0 9945 739 sff1_x4
xsubckt_8360_sff1_x4 1 1872 0 10025 1586 sff1_x4
xsubckt_7635_oa22_x2 0 7886 1 644 7679 697 oa22_x2
xsubckt_6917_mx2_x2 0 8380 1 710 1012 820 mx2_x2
xsubckt_6526_mx2_x2 0 2119 1 712 2120 2121 mx2_x2
xsubckt_6524_mx2_x2 0 2121 1 710 1469 1309 mx2_x2
xsubckt_6522_mx2_x2 0 2123 1 710 1437 1277 mx2_x2
xsubckt_6503_ao22_x2 0 2141 1 2145 2144 2142 ao22_x2
xsubckt_6049_nand3_x0 1 0 2585 2586 2593 7613 nand3_x0
xsubckt_5495_a4_x2 0 3047 1 3055 1864 1865 1866 a4_x2
xsubckt_5489_nor2_x0 1 0 3051 3055 1866 nor2_x0
xsubckt_4869_ao22_x2 0 3583 1 1760 3586 40 ao22_x2
xsubckt_3236_a3_x2 1 4733 0 4734 4735 4737 a3_x2
xsubckt_3109_a2_x2 0 4858 1 4864 703 a2_x2
xsubckt_2569_mx2_x2 0 5388 1 705 1009 817 mx2_x2
xsubckt_2567_mx2_x2 0 5390 1 705 1681 1553 mx2_x2
xsubckt_2542_a3_x2 1 5414 0 5415 5416 7104 a3_x2
xsubckt_296_inv_x0 1 0 961 7495 inv_x0
xsubckt_298_inv_x0 1 0 1536 7493 inv_x0
xsubckt_1974_oa22_x2 0 5890 1 186 215 574 oa22_x2
xsubckt_9779_sff1_x4 1 1872 0 8697 1700 sff1_x4
xsubckt_9691_sff1_x4 1 1872 0 8785 795 sff1_x4
xsubckt_9256_sff1_x4 1 1872 0 9205 322 sff1_x4
xsubckt_8805_sff1_x4 1 1872 0 9588 1763 sff1_x4
xsubckt_7234_a2_x2 0 8145 1 8146 8154 a2_x2
xsubckt_6934_ao22_x2 0 8363 1 1108 710 712 ao22_x2
xsubckt_6923_nand2_x0 1 0 8374 8375 712 nand2_x0
xsubckt_6139_mx2_x2 0 2497 1 7631 2498 2499 mx2_x2
xsubckt_6137_mx2_x2 0 2499 1 710 774 1638 mx2_x2
xsubckt_6091_mx2_x2 0 2544 1 710 1673 1545 mx2_x2
xsubckt_5789_a4_x2 0 2834 1 7198 7207 40 482 a4_x2
xsubckt_5611_a2_x2 0 9465 1 2963 2964 a2_x2
xsubckt_5420_nand3_x0 1 0 3105 40 116 7780 nand3_x0
xsubckt_4928_a3_x2 1 3539 0 40 54 7780 a3_x2
xsubckt_4728_nand2_x0 1 0 3691 3692 7707 nand2_x0
xsubckt_4694_a3_x2 1 9624 0 3721 3723 40 a3_x2
xsubckt_3493_nand3_x0 1 0 4481 4482 4638 5699 nand3_x0
xsubckt_2630_a2_x2 0 5328 1 5329 5333 a2_x2
xsubckt_1057_a2_x2 0 6765 1 7143 1866 a2_x2
xsubckt_1701_a2_x2 0 6140 1 446 230 a2_x2
xsubckt_9613_sff1_x4 1 1872 0 8860 841 sff1_x4
xsubckt_8879_sff1_x4 1 1872 0 9514 118 sff1_x4
xsubckt_8791_sff1_x4 1 1872 0 9602 1778 sff1_x4
xsubckt_8356_sff1_x4 1 1872 0 10029 1590 sff1_x4
xsubckt_8269_buf_x1 1 0 1735 8740 buf_x1
xsubckt_7548_a2_x2 0 7955 1 665 600 a2_x2
xsubckt_6619_a2_x2 0 2028 1 2029 7625 a2_x2
xsubckt_6385_a2_x2 0 9397 1 2257 2303 a2_x2
xsubckt_5691_a2_x2 0 2900 1 707 7357 a2_x2
xsubckt_5476_a2_x2 0 9502 1 3061 3062 a2_x2
xsubckt_5312_oa22_x2 0 3206 1 7680 3478 7167 oa22_x2
xsubckt_5154_ao22_x2 0 3351 1 644 3516 7168 ao22_x2
xsubckt_4988_a3_x2 1 3494 0 40 67 7780 a3_x2
xsubckt_4968_a3_x2 1 3509 0 40 72 7780 a3_x2
xsubckt_4948_a3_x2 1 3524 0 40 47 7780 a3_x2
xsubckt_4935_oa22_x2 0 9570 1 7168 3534 3536 oa22_x2
xsubckt_3813_a2_x2 0 10060 1 4167 4217 a2_x2
xsubckt_3658_a2_x2 0 4319 1 705 7432 a2_x2
xsubckt_2904_a2_x2 0 5059 1 5060 5586 a2_x2
xsubckt_2874_nand2_x0 1 0 5089 5090 5091 nand2_x0
xsubckt_2670_a2_x2 0 5289 1 5290 5293 a2_x2
xsubckt_781_nand2_x0 1 0 7028 7029 7030 nand2_x0
xsubckt_1292_a2_x2 0 6542 1 7143 1853 a2_x2
xsubckt_1904_nand2_x0 1 0 5954 6114 6356 nand2_x0
xsubckt_9687_sff1_x4 1 1872 0 8789 800 sff1_x4
xsubckt_9164_sff1_x4 1 1872 0 9294 585 sff1_x4
xsubckt_8713_sff1_x4 1 1872 0 9680 1113 sff1_x4
xsubckt_7445_nand2_x0 1 0 9242 8007 8010 nand2_x0
xsubckt_6653_nand2_x0 1 0 1994 1995 7628 nand2_x0
xsubckt_6208_oa22_x2 0 2430 1 40 1741 196 oa22_x2
xsubckt_5585_ao22_x2 0 2981 1 2986 1838 40 ao22_x2
xsubckt_5308_oa22_x2 0 3209 1 3214 3213 3210 oa22_x2
xsubckt_4424_mx3_x2 1 0 9838 3779 3896 1495 3817 3819 mx3_x2
xsubckt_4422_mx3_x2 1 0 9840 3779 3896 1497 3823 3825 mx3_x2
xsubckt_4420_mx3_x2 1 0 9842 3779 3896 1499 3829 3831 mx3_x2
xsubckt_3069_o3_x2 0 4897 1 4898 4900 7218 o3_x2
xsubckt_1117_xr2_x1 6708 0 1 694 69 xr2_x1
xsubckt_1071_xr2_x1 6752 0 1 696 71 xr2_x1
xsubckt_777_nand3_x0 1 0 7032 7033 7034 7035 nand3_x0
xsubckt_1464_xr2_x1 6377 0 1 185 214 xr2_x1
xsubckt_1751_nxr2_x1 6092 1 0 6093 6281 nxr2_x1
xsubckt_1839_nxr2_x1 6013 1 0 6014 6234 nxr2_x1
xsubckt_1992_nand2_x0 1 0 5874 5875 574 nand2_x0
xsubckt_9609_sff1_x4 1 1872 0 8864 845 sff1_x4
xsubckt_9521_sff1_x4 1 1872 0 8945 955 sff1_x4
xsubckt_8787_sff1_x4 1 1872 0 9606 1782 sff1_x4
xsubckt_8709_sff1_x4 1 1872 0 9684 1118 sff1_x4
xsubckt_7451_oa22_x2 0 9240 1 8150 8012 8003 oa22_x2
xsubckt_5957_mx2_x2 0 2675 1 710 748 1612 mx2_x2
xsubckt_5060_nand3_x0 1 0 3438 40 117 7780 nand3_x0
xsubckt_4428_mx3_x2 1 0 9834 3779 3896 1491 3805 3807 mx3_x2
xsubckt_4426_mx3_x2 1 0 9836 3779 3896 1493 3811 3813 mx3_x2
xsubckt_4380_mx3_x2 1 0 9879 3782 3896 993 3844 3846 mx3_x2
xsubckt_4037_mx3_x2 1 0 3947 707 705 3948 848 1360 mx3_x2
xsubckt_4033_mx3_x2 1 0 3951 707 705 3954 1232 1392 mx3_x2
xsubckt_2694_nand2_x0 1 0 5265 7152 7285 nand2_x0
xsubckt_1191_nand3_x0 1 0 6638 6659 6675 6677 nand3_x0
xsubckt_1280_o2_x2 0 6553 1 6554 6555 o2_x2
xsubckt_1514_o2_x2 0 6327 1 193 223 o2_x2
xsubckt_1634_nand2_x0 1 0 6207 194 224 nand2_x0
xsubckt_2423_o2_x2 0 5532 1 5533 707 o2_x2
xsubckt_2454_ao22_x2 0 5501 1 7598 7218 705 ao22_x2
xsubckt_9595_sff1_x4 1 1872 0 8878 920 sff1_x4
xsubckt_9517_sff1_x4 1 1872 0 8949 960 sff1_x4
xsubckt_9072_sff1_x4 1 1872 0 9354 1305 sff1_x4
xsubckt_8695_sff1_x4 1 1872 0 9698 1102 sff1_x4
xsubckt_8621_sff1_x4 1 1872 0 9772 1461 sff1_x4
xsubckt_6750_ao22_x2 0 8543 1 8544 8565 2729 ao22_x2
xsubckt_6393_o2_x2 0 2249 1 2250 711 o2_x2
xsubckt_5913_o2_x2 0 2718 1 2719 709 o2_x2
xsubckt_5187_nor3_x0 1 0 3321 3344 3508 3511 nor3_x0
xsubckt_4809_o2_x2 0 3628 1 3631 7711 o2_x2
xsubckt_4386_mx3_x2 1 0 9873 3782 3896 986 3826 3828 mx3_x2
xsubckt_4384_mx3_x2 1 0 9875 3782 3896 989 3832 3834 mx3_x2
xsubckt_4382_mx3_x2 1 0 9877 3782 3896 991 3838 3840 mx3_x2
xsubckt_3455_nxr2_x1 4519 1 0 4520 4521 nxr2_x1
xsubckt_890_nxr2_x1 6925 1 0 674 49 nxr2_x1
xsubckt_1379_o2_x2 0 6460 1 678 53 o2_x2
xsubckt_9068_sff1_x4 1 1872 0 9358 1310 sff1_x4
xsubckt_8617_sff1_x4 1 1872 0 9776 1465 sff1_x4
xsubckt_7447_oa22_x2 0 8005 1 644 7679 534 oa22_x2
xsubckt_7220_inv_x0 1 0 8155 9092 inv_x0
xsubckt_5409_nand3_x0 1 0 3115 3117 3157 3162 nand3_x0
xsubckt_5163_nxr2_x1 3343 1 0 3350 3513 nxr2_x1
xsubckt_4388_mx3_x2 1 0 9871 3782 3896 984 3820 3822 mx3_x2
xsubckt_4259_mx2_x2 0 9990 1 3791 3894 904 mx2_x2
xsubckt_3851_mx3_x2 1 0 4129 707 705 4130 1301 1461 mx3_x2
xsubckt_3720_mx2_x2 0 4258 1 706 4259 4261 mx2_x2
xsubckt_3115_mx3_x2 1 0 4852 707 705 4853 1059 1187 mx3_x2
xsubckt_3113_mx3_x2 1 0 4854 707 705 4855 963 1123 mx3_x2
xsubckt_2757_o2_x2 0 5204 1 201 673 o2_x2
xsubckt_745_a4_x2 0 7060 1 1738 585 40 7790 a4_x2
xsubckt_670_nand3_x0 1 0 7125 7126 7128 7129 nand3_x0
xsubckt_1263_oa22_x2 0 155 1 1740 6580 6570 oa22_x2
xsubckt_1364_nand2_x0 1 0 6474 680 55 nand2_x0
xsubckt_1454_nand2_x0 1 0 6387 182 211 nand2_x0
xsubckt_1848_o2_x2 0 6005 1 6006 6318 o2_x2
xsubckt_1985_ao22_x2 0 5880 1 6398 5882 6111 ao22_x2
xsubckt_9860_sff1_x4 1 1872 0 8616 1234 sff1_x4
xsubckt_9425_sff1_x4 1 1872 0 9041 1369 sff1_x4
xsubckt_6466_nor2_x0 1 0 2177 2178 711 nor2_x0
xsubckt_6223_ao22_x2 0 2415 1 2416 2418 2419 ao22_x2
xsubckt_5647_oa22_x2 0 2936 1 1820 2943 1819 oa22_x2
xsubckt_5124_oa22_x2 0 3379 1 3387 3385 3386 oa22_x2
xsubckt_3726_mx2_x2 0 4252 1 703 4253 4258 mx2_x2
xsubckt_1274_nand2_x0 1 0 6559 587 1755 nand2_x0
xsubckt_2358_ao22_x2 0 5596 1 7696 7192 5597 ao22_x2
xsubckt_9499_sff1_x4 1 1872 0 8967 1168 sff1_x4
xsubckt_8960_sff1_x4 1 1872 0 166 103 sff1_x4
xsubckt_8525_sff1_x4 1 1872 0 9868 981 sff1_x4
xsubckt_7770_mx3_x2 1 0 9097 7828 3896 1040 3799 3801 mx3_x2
xsubckt_7554_ao22_x2 0 9190 1 7950 7956 7959 ao22_x2
xsubckt_7036_mx3_x2 1 0 8264 712 710 8265 1520 1648 mx3_x2
xsubckt_5566_nor2_x0 1 0 2995 2999 1843 nor2_x0
xsubckt_4195_nor3_x0 1 0 3815 3821 7743 7744 nor3_x0
xsubckt_3728_mx2_x2 0 4250 1 705 1719 887 mx2_x2
xsubckt_3680_mx2_x2 0 4297 1 705 1016 824 mx2_x2
xsubckt_3111_nand2_x0 1 0 4856 4857 7216 nand2_x0
xsubckt_2583_nand3_x0 1 0 5374 5375 5376 7104 nand3_x0
xsubckt_1171_oa22_x2 0 6657 1 6677 6675 6658 oa22_x2
xsubckt_698_a3_x2 1 7103 0 7107 7683 1739 a3_x2
xsubckt_678_a3_x2 1 7118 0 7124 7130 7135 a3_x2
xsubckt_1616_oa22_x2 0 6225 1 6227 6228 6318 oa22_x2
xsubckt_2405_nand3_x0 1 0 5549 5550 5552 7216 nand3_x0
xsubckt_9856_sff1_x4 1 1872 0 8620 1238 sff1_x4
xsubckt_9333_sff1_x4 1 1872 0 9128 1327 sff1_x4
xsubckt_8599_sff1_x4 1 1872 0 9794 1454 sff1_x4
xsubckt_6805_nand2_x0 1 0 8490 8491 8492 nand2_x0
xsubckt_5302_nand3_x0 1 0 3215 3216 3222 3226 nand3_x0
xsubckt_3818_nand2_x0 1 0 4162 211 683 nand2_x0
xsubckt_3688_mx2_x2 0 4289 1 705 1432 1272 mx2_x2
xsubckt_3686_mx2_x2 0 4291 1 7217 7426 7429 mx2_x2
xsubckt_3523_ao22_x2 0 4452 1 4453 4460 703 ao22_x2
xsubckt_3285_nand3_x0 1 0 4685 4686 4843 5699 nand3_x0
xsubckt_652_nor3_x0 1 0 7143 587 588 589 nor3_x0
xsubckt_535_inv_x0 1 0 206 7256 inv_x0
xsubckt_144_inv_x0 1 0 347 7647 inv_x0
xsubckt_142_inv_x0 1 0 646 7649 inv_x0
xsubckt_140_inv_x0 1 0 664 7651 inv_x0
xsubckt_531_inv_x0 1 0 211 7260 inv_x0
xsubckt_533_inv_x0 1 0 209 7258 inv_x0
xsubckt_2067_oa22_x2 0 5805 1 7788 5810 5806 oa22_x2
xsubckt_2151_mx3_x2 1 0 452 7162 5754 203 81 113 mx3_x2
xsubckt_2153_mx3_x2 1 0 450 7162 5754 201 79 111 mx3_x2
xsubckt_2155_mx3_x2 1 0 448 7162 5754 199 77 109 mx3_x2
xsubckt_8956_sff1_x4 1 1872 0 140 77 sff1_x4
xsubckt_8433_sff1_x4 1 1872 0 9960 880 sff1_x4
xsubckt_7685_nand2_x0 1 0 7845 664 600 nand2_x0
xsubckt_6721_mx2_x2 0 8572 1 710 1016 824 mx2_x2
xsubckt_6363_oa22_x2 0 2278 1 7625 1441 2279 oa22_x2
xsubckt_6127_ao22_x2 0 2509 1 7620 2513 2510 ao22_x2
xsubckt_5833_nand2_x0 1 0 2793 2794 2796 nand2_x0
xsubckt_5627_a4_x2 0 2951 1 2959 1824 1825 1827 a4_x2
xsubckt_5424_nxr2_x1 3101 1 0 3457 665 nxr2_x1
xsubckt_4655_oa22_x2 0 3750 1 3754 3763 1773 oa22_x2
xsubckt_2893_mx3_x2 1 0 5070 707 705 5071 1033 1161 mx3_x2
xsubckt_2846_nand2_x0 1 0 5116 7153 7280 nand2_x0
xsubckt_2764_mx2_x2 0 5197 1 705 1419 1259 mx2_x2
xsubckt_539_inv_x0 1 0 445 7252 inv_x0
xsubckt_537_inv_x0 1 0 205 7254 inv_x0
xsubckt_148_inv_x0 1 0 409 7643 inv_x0
xsubckt_146_inv_x0 1 0 404 7645 inv_x0
xsubckt_491_inv_x0 1 0 1880 7300 inv_x0
xsubckt_493_inv_x0 1 0 1879 7298 inv_x0
xsubckt_1964_nand2_x0 1 0 5899 6112 6375 nand2_x0
xsubckt_2157_mx3_x2 1 0 476 7162 5754 227 105 137 mx3_x2
xsubckt_2159_mx3_x2 1 0 474 7162 5754 225 103 135 mx3_x2
xsubckt_9764_sff1_x4 1 1872 0 8712 1714 sff1_x4
xsubckt_9329_sff1_x4 1 1872 0 9132 1332 sff1_x4
xsubckt_9241_sff1_x4 1 1872 0 9220 338 sff1_x4
xsubckt_8429_sff1_x4 1 1872 0 9964 885 sff1_x4
xsubckt_6727_nor2_x0 1 0 8566 8567 8568 nor2_x0
xsubckt_6535_nand2_x0 1 0 2110 2112 7628 nand2_x0
xsubckt_6330_mx2_x2 0 2310 1 708 2311 2313 mx2_x2
xsubckt_5662_ao22_x2 0 2925 1 2930 1814 40 ao22_x2
xsubckt_5653_nand2_x0 1 0 2932 2935 1817 nand2_x0
xsubckt_5461_a3_x2 1 9506 0 3072 3073 40 a3_x2
xsubckt_5382_nor2_x0 1 0 3140 3141 3143 nor2_x0
xsubckt_4758_a4_x2 0 3667 1 3671 3707 3711 1790 a4_x2
xsubckt_3458_nand2_x0 1 0 4516 4517 7219 nand2_x0
xsubckt_3222_a2_x2 0 4747 1 4748 4753 a2_x2
xsubckt_2899_mx3_x2 1 0 5064 707 705 5065 1577 713 mx3_x2
xsubckt_2897_mx3_x2 1 0 5066 707 705 5067 1513 1641 mx3_x2
xsubckt_2766_mx2_x2 0 5195 1 7217 7556 7558 mx2_x2
xsubckt_2666_nand2_x0 1 0 5293 5294 5295 nand2_x0
xsubckt_1130_a2_x2 0 6695 1 222 1739 a2_x2
xsubckt_1104_mx2_x2 0 6720 1 7786 6722 7787 mx2_x2
xsubckt_1075_oa22_x2 0 6748 1 6771 6756 6751 oa22_x2
xsubckt_686_o3_x2 0 299 1 602 580 579 o3_x2
xsubckt_495_inv_x0 1 0 400 7296 inv_x0
xsubckt_497_inv_x0 1 0 218 7294 inv_x0
xsubckt_499_inv_x0 1 0 207 7292 inv_x0
xsubckt_1723_ao22_x2 0 6118 1 6119 6142 535 ao22_x2
xsubckt_1784_nand2_x0 1 0 6063 6112 6295 nand2_x0
xsubckt_1874_nand2_x0 1 0 5981 6112 6209 nand2_x0
xsubckt_8864_sff1_x4 1 1872 0 9529 134 sff1_x4
xsubckt_8341_sff1_x4 1 1872 0 10044 1606 sff1_x4
xsubckt_7601_a2_x2 0 7914 1 666 600 a2_x2
xsubckt_6729_mx2_x2 0 8564 1 710 728 1592 mx2_x2
xsubckt_6716_oa22_x2 0 8577 1 7427 7625 7631 oa22_x2
xsubckt_6681_mx2_x2 0 1967 1 710 761 1625 mx2_x2
xsubckt_6470_ao22_x2 0 9395 1 2174 2176 2213 ao22_x2
xsubckt_6068_a2_x2 0 9404 1 2567 2609 a2_x2
xsubckt_5932_mx3_x2 1 0 2699 7613 7620 2700 2707 2710 mx3_x2
xsubckt_5354_a2_x2 0 3166 1 3471 665 a2_x2
xsubckt_4826_a3_x2 1 9597 0 3616 3618 40 a3_x2
xsubckt_4397_a3_x2 1 3780 0 519 7210 7211 a3_x2
xsubckt_3711_nand2_x0 1 0 4267 213 685 nand2_x0
xsubckt_3047_a2_x2 0 4919 1 4920 7217 a2_x2
xsubckt_1249_a2_x2 0 6583 1 686 61 a2_x2
xsubckt_9672_sff1_x4 1 1872 0 8804 807 sff1_x4
xsubckt_9237_sff1_x4 1 1872 0 9224 312 sff1_x4
xsubckt_8772_sff1_x4 1 1872 0 9621 1799 sff1_x4
xsubckt_8337_sff1_x4 1 1872 0 10048 1580 sff1_x4
xsubckt_7466_a2_x2 0 7994 1 7199 7207 a2_x2
xsubckt_7057_nand2_x0 1 0 8243 8244 7631 nand2_x0
xsubckt_6689_mx2_x2 0 1959 1 712 1960 1961 mx2_x2
xsubckt_6687_mx2_x2 0 1961 1 710 1465 1305 mx2_x2
xsubckt_6296_mx2_x2 0 2344 1 712 1154 1122 mx2_x2
xsubckt_5803_mx2_x2 0 2823 1 710 1160 1000 mx2_x2
xsubckt_5795_a3_x2 1 2830 0 7195 40 481 a3_x2
xsubckt_5608_a2_x2 0 9466 1 2965 2966 a2_x2
xsubckt_4739_a2_x2 0 9617 1 3683 3684 a2_x2
xsubckt_4677_nand3_x0 1 0 3733 3739 1745 1744 nand3_x0
xsubckt_3147_nor2_x0 1 0 4821 4822 4825 nor2_x0
xsubckt_1030_o3_x2 0 6791 1 405 308 307 o3_x2
xsubckt_1426_nand2_x0 1 0 6415 180 209 nand2_x0
xsubckt_1865_a3_x2 1 5989 0 5990 5991 5992 a3_x2
xsubckt_1913_a2_x2 0 5946 1 5947 5950 a2_x2
xsubckt_2218_nand2_x0 1 0 5733 5735 5737 nand2_x0
xsubckt_9668_sff1_x4 1 1872 0 8808 818 sff1_x4
xsubckt_9145_sff1_x4 1 1872 0 9313 1138 sff1_x4
xsubckt_7310_nand2_x0 1 0 8090 8091 8095 nand2_x0
xsubckt_6514_nand3_x0 1 0 2130 2131 2155 2729 nand3_x0
xsubckt_6298_mx2_x2 0 2342 1 712 1090 1058 mx2_x2
xsubckt_6085_nand2_x0 1 0 2550 2552 7628 nand2_x0
xsubckt_5763_mx2_x2 0 9420 1 2856 458 495 mx2_x2
xsubckt_5761_mx2_x2 0 9422 1 2856 460 497 mx2_x2
xsubckt_4623_mx3_x2 1 0 9653 3765 3896 1279 3838 3840 mx3_x2
xsubckt_4621_mx3_x2 1 0 9655 3765 3896 1281 3844 3846 mx3_x2
xsubckt_3578_nor2_x0 1 0 4398 215 687 nor2_x0
xsubckt_9580_sff1_x4 1 1872 0 8893 906 sff1_x4
xsubckt_9502_sff1_x4 1 1872 0 8964 967 sff1_x4
xsubckt_8768_sff1_x4 1 1872 0 9625 1803 sff1_x4
xsubckt_8680_sff1_x4 1 1872 0 9713 1434 sff1_x4
xsubckt_7913_nand4_x0 1 0 7815 3769 3901 3903 3906 nand4_x0
xsubckt_7581_o3_x2 0 7929 1 7930 7952 7955 o3_x2
xsubckt_7561_o3_x2 0 7944 1 7945 7952 7955 o3_x2
xsubckt_5767_mx2_x2 0 2855 1 7084 7691 484 mx2_x2
xsubckt_5765_mx2_x2 0 9418 1 2856 455 492 mx2_x2
xsubckt_5322_o2_x2 0 3196 1 3197 7690 o2_x2
xsubckt_4666_ao22_x2 0 3742 1 1746 3745 40 ao22_x2
xsubckt_4629_mx3_x2 1 0 9647 3765 3896 1272 3820 3822 mx3_x2
xsubckt_4627_mx3_x2 1 0 9649 3765 3896 1274 3826 3828 mx3_x2
xsubckt_4625_mx3_x2 1 0 9651 3765 3896 1277 3832 3834 mx3_x2
xsubckt_4236_mx3_x2 1 0 10010 3795 3896 1572 3853 3855 mx3_x2
xsubckt_4234_mx3_x2 1 0 10012 3795 3897 1574 3859 3860 mx3_x2
xsubckt_4232_mx3_x2 1 0 10014 3795 3897 1546 3867 3868 mx3_x2
xsubckt_4103_mx2_x2 0 10051 1 3898 3886 1585 mx2_x2
xsubckt_4101_mx2_x2 0 3887 1 518 85 1881 mx2_x2
xsubckt_3351_nand2_x0 1 0 4621 4622 4625 nand2_x0
xsubckt_2870_ao22_x2 0 5093 1 809 7217 7219 ao22_x2
xsubckt_1156_nand2_x0 1 0 6671 6672 6719 nand2_x0
xsubckt_993_nand2_x0 1 0 6826 1834 589 nand2_x0
xsubckt_60_inv_x0 1 0 74 7731 inv_x0
xsubckt_2038_nand2_x0 1 0 5831 6114 6416 nand2_x0
xsubckt_9576_sff1_x4 1 1872 0 8897 910 sff1_x4
xsubckt_9053_sff1_x4 1 1872 0 9373 1297 sff1_x4
xsubckt_8602_sff1_x4 1 1872 0 9791 1451 sff1_x4
xsubckt_6819_o2_x2 0 8476 1 8477 7631 o2_x2
xsubckt_5671_nxr2_x1 2919 1 0 2922 7255 nxr2_x1
xsubckt_5628_nand4_x0 1 0 2950 2959 1824 1825 1827 nand4_x0
xsubckt_5400_ao22_x2 0 3123 1 3128 3125 3124 ao22_x2
xsubckt_4585_mx3_x2 1 0 9688 3768 3896 1122 3847 3849 mx3_x2
xsubckt_4583_mx3_x2 1 0 9690 3768 3896 1124 3853 3855 mx3_x2
xsubckt_4581_mx3_x2 1 0 9692 3768 3897 1126 3859 3860 mx3_x2
xsubckt_4238_mx3_x2 1 0 10008 3795 3896 1570 3847 3849 mx3_x2
xsubckt_4107_mx2_x2 0 3882 1 3896 3883 3884 mx2_x2
xsubckt_3044_oa22_x2 0 4922 1 4923 705 707 oa22_x2
xsubckt_2921_nor3_x0 1 0 5043 5044 5045 7180 nor3_x0
xsubckt_871_nxr2_x1 6943 1 0 6944 6947 nxr2_x1
xsubckt_815_nand2_x0 1 0 6996 588 1795 nand2_x0
xsubckt_600_ao22_x2 0 7191 1 7782 7194 40 ao22_x2
xsubckt_66_inv_x0 1 0 50 7725 inv_x0
xsubckt_64_inv_x0 1 0 48 7727 inv_x0
xsubckt_62_inv_x0 1 0 46 7729 inv_x0
xsubckt_1452_o2_x2 0 6389 1 182 211 o2_x2
xsubckt_1472_o2_x2 0 6369 1 187 216 o2_x2
xsubckt_2111_nand2_x0 1 0 441 5771 5774 nand2_x0
xsubckt_9410_sff1_x4 1 1872 0 9056 1355 sff1_x4
xsubckt_8676_sff1_x4 1 1872 0 9717 1439 sff1_x4
xsubckt_8022_mx2_x2 0 8831 1 7809 3874 812 mx2_x2
xsubckt_8020_mx2_x2 0 8833 1 7809 3882 814 mx2_x2
xsubckt_6859_o2_x2 0 8437 1 8438 8440 o2_x2
xsubckt_5983_nand2_x0 1 0 2650 2651 2652 nand2_x0
xsubckt_4589_mx3_x2 1 0 9684 3768 3896 1118 3835 3837 mx3_x2
xsubckt_4587_mx3_x2 1 0 9686 3768 3896 1120 3841 3843 mx3_x2
xsubckt_2804_nand4_x0 1 0 5157 5604 532 7689 48 nand4_x0
xsubckt_1086_ao22_x2 0 6737 1 6738 6742 7038 ao22_x2
xsubckt_68_inv_x0 1 0 65 7723 inv_x0
xsubckt_1244_oa22_x2 0 156 1 1740 6598 6588 oa22_x2
xsubckt_1315_nand3_x0 1 0 6520 6521 6522 6523 nand3_x0
xsubckt_9484_sff1_x4 1 1872 0 8982 1185 sff1_x4
xsubckt_9049_sff1_x4 1 1872 0 9377 645 sff1_x4
xsubckt_8510_sff1_x4 1 1872 0 9883 997 sff1_x4
xsubckt_8159_mx3_x2 1 0 8670 7802 3897 1643 3871 3872 mx3_x2
xsubckt_7477_nand2_x0 1 0 7984 7985 7988 nand2_x0
xsubckt_6507_nand2_x0 1 0 2137 2138 712 nand2_x0
xsubckt_6204_ao22_x2 0 2433 1 534 532 699 ao22_x2
xsubckt_6005_oa22_x2 0 2628 1 7625 1419 2629 oa22_x2
xsubckt_5715_nand2_x0 1 0 2876 2877 2879 nand2_x0
xsubckt_5183_oa22_x2 0 3324 1 7102 3329 3325 oa22_x2
xsubckt_3534_mx2_x2 0 4441 1 705 762 1626 mx2_x2
xsubckt_3239_ao22_x2 0 10070 1 4731 4771 4779 ao22_x2
xsubckt_3141_mx2_x2 0 4827 1 705 1154 994 mx2_x2
xsubckt_2638_nand2_x0 1 0 5320 7152 7288 nand2_x0
xsubckt_1636_nxr2_x1 6205 1 0 194 224 nxr2_x1
xsubckt_9841_sff1_x4 1 1872 0 8635 1254 sff1_x4
xsubckt_9406_sff1_x4 1 1872 0 9060 1361 sff1_x4
xsubckt_8584_sff1_x4 1 1872 0 9809 1018 sff1_x4
xsubckt_8506_sff1_x4 1 1872 0 9887 971 sff1_x4
xsubckt_7971_mx3_x2 1 0 8878 7814 3896 920 3820 3822 mx3_x2
xsubckt_7104_mx2_x2 0 8197 1 712 8198 8199 mx2_x2
xsubckt_7102_mx2_x2 0 8199 1 710 1455 1295 mx2_x2
xsubckt_5827_ao22_x2 0 2799 1 7631 2800 7620 ao22_x2
xsubckt_5105_oa22_x2 0 3396 1 7680 3529 7167 oa22_x2
xsubckt_3927_mx2_x2 0 4055 1 705 755 1619 mx2_x2
xsubckt_3881_mx2_x2 0 4100 1 705 1140 980 mx2_x2
xsubckt_3839_nor2_x0 1 0 4141 4142 4144 nor2_x0
xsubckt_3344_nxr2_x1 4628 1 0 4629 4632 nxr2_x1
xsubckt_1152_oa22_x2 0 6675 1 6692 6690 6676 oa22_x2
xsubckt_9837_sff1_x4 1 1872 0 8639 1228 sff1_x4
xsubckt_9392_sff1_x4 1 1872 0 9069 358 sff1_x4
xsubckt_8941_sff1_x4 1 1872 0 9452 1816 sff1_x4
xsubckt_7977_mx3_x2 1 0 8872 7814 3896 914 3802 3804 mx3_x2
xsubckt_7975_mx3_x2 1 0 8874 7814 3896 916 3808 3810 mx3_x2
xsubckt_7973_mx3_x2 1 0 8876 7814 3896 918 3814 3816 mx3_x2
xsubckt_7453_mx2_x2 0 9239 1 8139 8002 530 mx2_x2
xsubckt_7303_a4_x2 0 8095 1 538 7679 644 40 a4_x2
xsubckt_7193_mx3_x2 1 0 9332 8158 3897 1158 3859 3860 mx3_x2
xsubckt_7191_mx3_x2 1 0 9334 8158 3897 1130 3867 3868 mx3_x2
xsubckt_7108_mx2_x2 0 8193 1 710 1167 1039 mx2_x2
xsubckt_7106_mx2_x2 0 8195 1 710 1359 847 mx2_x2
xsubckt_6190_ao22_x2 0 2447 1 2452 2450 2448 ao22_x2
xsubckt_5378_ao22_x2 0 3144 1 3468 3471 665 ao22_x2
xsubckt_5179_oa22_x2 0 3328 1 7680 3511 7167 oa22_x2
xsubckt_4640_oa22_x2 0 3761 1 1742 644 1807 oa22_x2
xsubckt_4152_nxr2_x1 3847 1 0 3851 7734 nxr2_x1
xsubckt_3887_mx2_x2 0 4094 1 705 1716 884 mx2_x2
xsubckt_3885_mx2_x2 0 4096 1 7219 4097 4098 mx2_x2
xsubckt_3883_mx2_x2 0 4098 1 705 1428 1268 mx2_x2
xsubckt_2612_mx2_x2 0 5346 1 706 5347 5349 mx2_x2
xsubckt_2610_mx2_x2 0 5348 1 705 1198 1070 mx2_x2
xsubckt_938_a2_x2 0 6879 1 7786 525 a2_x2
xsubckt_918_a2_x2 0 6898 1 201 1739 a2_x2
xsubckt_882_nand3_x0 1 0 6932 6933 6934 6935 nand3_x0
xsubckt_341_inv_x0 1 0 1434 7450 inv_x0
xsubckt_343_inv_x0 1 0 1274 7448 inv_x0
xsubckt_2048_oa22_x2 0 5822 1 6409 6116 6112 oa22_x2
xsubckt_2221_mx2_x2 0 5730 1 710 1212 1084 mx2_x2
xsubckt_9388_sff1_x4 1 1872 0 9073 362 sff1_x4
xsubckt_9314_sff1_x4 1 1872 0 9147 1348 sff1_x4
xsubckt_8937_sff1_x4 1 1872 0 9456 1820 sff1_x4
xsubckt_8492_sff1_x4 1 1872 0 9901 1526 sff1_x4
xsubckt_8414_sff1_x4 1 1872 0 9979 901 sff1_x4
xsubckt_8252_nand2_x0 1 0 7796 7200 7207 nand2_x0
xsubckt_7979_mx3_x2 1 0 8870 7814 3896 911 3797 3798 mx3_x2
xsubckt_7848_mx2_x2 0 8995 1 7819 3890 1180 mx2_x2
xsubckt_7846_mx2_x2 0 8997 1 7819 3894 1192 mx2_x2
xsubckt_7460_nand2_x0 1 0 7998 7151 7789 nand2_x0
xsubckt_7459_mx2_x2 0 9236 1 5752 7999 537 mx2_x2
xsubckt_7457_mx2_x2 0 9237 1 5752 8000 538 mx2_x2
xsubckt_7455_mx2_x2 0 9238 1 5752 8001 2853 mx2_x2
xsubckt_7199_mx3_x2 1 0 9326 8158 3896 1152 3841 3843 mx3_x2
xsubckt_7197_mx3_x2 1 0 9328 8158 3896 1154 3847 3849 mx3_x2
xsubckt_7195_mx3_x2 1 0 9330 8158 3896 1156 3853 3855 mx3_x2
xsubckt_6400_nand2_x0 1 0 2242 2243 712 nand2_x0
xsubckt_5405_nxr2_x1 3119 1 0 3127 3460 nxr2_x1
xsubckt_4148_nxr2_x1 3850 1 0 3854 7733 nxr2_x1
xsubckt_3889_mx2_x2 0 4092 1 705 756 1620 mx2_x2
xsubckt_3291_oa22_x2 0 4680 1 5595 5608 221 oa22_x2
xsubckt_2570_mx2_x2 0 5387 1 707 5388 5389 mx2_x2
xsubckt_2544_a4_x2 0 5412 1 5604 532 7689 65 a4_x2
xsubckt_2531_nand2_x0 1 0 5425 5426 5435 nand2_x0
xsubckt_1148_oa22_x2 0 6678 1 6719 6687 6679 oa22_x2
xsubckt_804_mx2_x2 0 7007 1 229 407 390 mx2_x2
xsubckt_690_inv_x0 1 0 7111 9377 inv_x0
xsubckt_345_inv_x0 1 0 1114 7446 inv_x0
xsubckt_347_inv_x0 1 0 1050 7444 inv_x0
xsubckt_349_inv_x0 1 0 1721 7442 inv_x0
xsubckt_1218_nand2_x0 1 0 6612 588 1793 nand2_x0
xsubckt_1486_nand2_x0 1 0 6355 191 221 nand2_x0
xsubckt_1901_nxr2_x1 5957 1 0 5958 6353 nxr2_x1
xsubckt_2225_mx2_x2 0 5726 1 710 1500 1340 mx2_x2
xsubckt_2227_mx2_x2 0 5724 1 710 1468 1308 mx2_x2
xsubckt_9745_sff1_x4 1 1872 0 8731 1734 sff1_x4
xsubckt_9222_sff1_x4 1 1872 0 299 527 sff1_x4
xsubckt_8488_sff1_x4 1 1872 0 9905 1530 sff1_x4
xsubckt_7608_nor2_x0 1 0 7908 7909 7910 nor2_x0
xsubckt_7236_a3_x2 1 8144 0 9090 8152 9089 a3_x2
xsubckt_6924_mx2_x2 0 8373 1 710 1716 884 mx2_x2
xsubckt_6310_nand2_x0 1 0 2330 2331 711 nand2_x0
xsubckt_6142_mx2_x2 0 2494 1 712 2495 2496 mx2_x2
xsubckt_6140_mx2_x2 0 2496 1 710 1382 870 mx2_x2
xsubckt_4293_nand2_x0 1 0 3788 3790 3900 nand2_x0
xsubckt_3248_nxr2_x1 4722 1 0 4723 4728 nxr2_x1
xsubckt_2574_mx2_x2 0 5383 1 7217 7585 7587 mx2_x2
xsubckt_2572_mx2_x2 0 5385 1 7217 7581 7583 mx2_x2
xsubckt_2479_oa22_x2 0 5476 1 5477 5490 5593 oa22_x2
xsubckt_760_mx2_x2 0 7048 1 229 379 392 mx2_x2
xsubckt_655_nor2_x0 1 0 7140 605 604 nor2_x0
xsubckt_612_o2_x2 0 7179 1 1738 1737 o2_x2
xsubckt_2181_mx2_x2 0 9079 1 7199 401 369 mx2_x2
xsubckt_2183_mx2_x2 0 9078 1 7199 400 368 mx2_x2
xsubckt_2185_mx2_x2 0 9077 1 7199 399 367 mx2_x2
xsubckt_2211_a2_x2 0 5740 1 5741 709 a2_x2
xsubckt_9296_sff1_x4 1 1872 0 9165 674 sff1_x4
xsubckt_8845_sff1_x4 1 1872 0 9548 58 sff1_x4
xsubckt_8322_sff1_x4 1 1872 0 10063 215 sff1_x4
xsubckt_8274_buf_x1 1 0 1708 8735 buf_x1
xsubckt_8272_buf_x1 1 0 1710 8737 buf_x1
xsubckt_8270_buf_x1 1 0 1724 8739 buf_x1
xsubckt_7705_nand4_x0 1 0 7829 3766 3901 3903 3906 nand4_x0
xsubckt_7471_a3_x2 1 7989 0 7204 344 7703 a3_x2
xsubckt_7439_ao22_x2 0 8011 1 7131 7195 533 ao22_x2
xsubckt_7071_nor2_x0 1 0 8229 8230 7134 nor2_x0
xsubckt_6927_nand2_x0 1 0 8370 8371 7628 nand2_x0
xsubckt_6880_mx2_x2 0 8416 1 710 1013 821 mx2_x2
xsubckt_6491_mx2_x2 0 2153 1 710 1502 1342 mx2_x2
xsubckt_6148_mx2_x2 0 2488 1 712 2489 2490 mx2_x2
xsubckt_6146_mx2_x2 0 2490 1 710 1478 1318 mx2_x2
xsubckt_6144_mx2_x2 0 2492 1 710 1222 1094 mx2_x2
xsubckt_5886_nor2_x0 1 0 2741 2742 2743 nor2_x0
xsubckt_5643_ao22_x2 0 2939 1 2943 1820 40 ao22_x2
xsubckt_5514_nand3_x0 1 0 3033 3039 1858 1860 nand3_x0
xsubckt_5458_a3_x2 1 3074 0 3079 1826 1837 a3_x2
xsubckt_4696_a4_x2 0 3719 1 1745 1744 1803 1802 a4_x2
xsubckt_3750_nand3_x0 1 0 4228 4229 4230 7216 nand3_x0
xsubckt_3233_nand2_x0 1 0 4736 7153 7273 nand2_x0
xsubckt_2700_a2_x2 0 10080 1 5260 5310 a2_x2
xsubckt_1099_a3_x2 1 6725 0 384 307 229 a3_x2
xsubckt_1056_oa22_x2 0 6766 1 525 6899 6767 oa22_x2
xsubckt_843_ao22_x2 0 6969 1 6970 6974 7038 ao22_x2
xsubckt_766_mx2_x2 0 7042 1 307 7678 7687 mx2_x2
xsubckt_1342_a2_x2 0 6495 1 681 56 a2_x2
xsubckt_2076_a2_x2 0 5798 1 7043 7053 a2_x2
xsubckt_2098_nand2_x0 1 0 5781 197 307 nand2_x0
xsubckt_2187_mx2_x2 0 9076 1 7199 398 366 mx2_x2
xsubckt_2189_mx2_x2 0 9075 1 7199 396 364 mx2_x2
xsubckt_2271_a2_x2 0 5681 1 5682 7625 a2_x2
xsubckt_9653_sff1_x4 1 1872 0 8823 834 sff1_x4
xsubckt_9218_sff1_x4 1 1872 0 9241 534 sff1_x4
xsubckt_9130_sff1_x4 1 1872 0 9328 1154 sff1_x4
xsubckt_8396_sff1_x4 1 1872 0 10094 711 sff1_x4
xsubckt_8278_buf_x1 1 0 1734 8731 buf_x1
xsubckt_8276_buf_x1 1 0 1706 8733 buf_x1
xsubckt_7615_nand4_x0 1 0 7902 7903 7951 7957 8140 nand4_x0
xsubckt_7583_oa22_x2 0 7928 1 644 7679 686 oa22_x2
xsubckt_7384_a2_x2 0 8034 1 349 351 a2_x2
xsubckt_6630_a2_x2 0 2017 1 2020 7613 a2_x2
xsubckt_5875_oa22_x2 0 2752 1 2753 710 7631 oa22_x2
xsubckt_4363_a2_x2 0 3782 1 3783 3796 a2_x2
xsubckt_3053_nand2_x0 1 0 4913 4914 704 nand2_x0
xsubckt_2968_nand2_x0 1 0 4997 5001 5048 nand2_x0
xsubckt_2705_nxr2_x1 5255 1 0 5256 5259 nxr2_x1
xsubckt_2692_a3_x2 1 5267 0 5268 5416 5699 a3_x2
xsubckt_1656_a2_x2 0 6185 1 6186 6188 a2_x2
xsubckt_8753_sff1_x4 1 1872 0 9640 1264 sff1_x4
xsubckt_8318_sff1_x4 1 1872 0 10067 220 sff1_x4
xsubckt_5962_mx2_x2 0 2670 1 710 1452 1292 mx2_x2
xsubckt_5586_a2_x2 0 9472 1 2981 2982 a2_x2
xsubckt_4975_oa22_x2 0 9560 1 7168 3504 3506 oa22_x2
xsubckt_4697_a2_x2 0 3718 1 3719 3720 a2_x2
xsubckt_4657_a2_x2 0 3749 1 1773 1762 a2_x2
xsubckt_4431_mx3_x2 1 0 9831 3779 3896 1487 3797 3798 mx3_x2
xsubckt_3943_a2_x2 0 4039 1 4040 4045 a2_x2
xsubckt_2878_nand2_x0 1 0 5085 5086 5087 nand2_x0
xsubckt_2788_nand2_x0 1 0 5173 5174 5175 nand2_x0
xsubckt_2508_ao22_x2 0 5448 1 7592 7217 707 ao22_x2
xsubckt_978_xr2_x1 6841 0 1 700 75 xr2_x1
xsubckt_1409_oa22_x2 0 146 1 6443 6442 6432 oa22_x2
xsubckt_1515_xr2_x1 6326 0 1 193 223 xr2_x1
xsubckt_1844_oa22_x2 0 1933 1 6111 6013 6009 oa22_x2
xsubckt_9649_sff1_x4 1 1872 0 8827 838 sff1_x4
xsubckt_9561_sff1_x4 1 1872 0 8912 1210 sff1_x4
xsubckt_9126_sff1_x4 1 1872 0 9332 1158 sff1_x4
xsubckt_8749_sff1_x4 1 1872 0 9644 1269 sff1_x4
xsubckt_8001_mx3_x2 1 0 8850 7812 3896 861 3832 3834 mx3_x2
xsubckt_7702_nand2_x0 1 0 7831 7832 7833 nand2_x0
xsubckt_7579_oa22_x2 0 7931 1 644 7679 685 oa22_x2
xsubckt_6882_ao22_x2 0 8414 1 8418 8417 8415 ao22_x2
xsubckt_6804_ao22_x2 0 8491 1 7411 7625 712 ao22_x2
xsubckt_5982_ao22_x2 0 2651 1 7562 710 712 ao22_x2
xsubckt_5968_mx2_x2 0 2664 1 710 1420 1260 mx2_x2
xsubckt_5964_mx2_x2 0 2668 1 712 2669 2670 mx2_x2
xsubckt_4300_mx2_x2 0 9952 1 3788 3874 716 mx2_x2
xsubckt_4040_mx3_x2 1 0 3944 707 705 3945 784 912 mx3_x2
xsubckt_1214_nor3_x0 1 0 6616 6617 6618 7791 nor3_x0
xsubckt_1395_oa22_x2 0 6445 1 6457 6460 6461 oa22_x2
xsubckt_1475_xr2_x1 6366 0 1 187 216 xr2_x1
xsubckt_8661_sff1_x4 1 1872 0 9732 1436 sff1_x4
xsubckt_8007_mx3_x2 1 0 8844 7812 3896 854 3814 3816 mx3_x2
xsubckt_8005_mx3_x2 1 0 8846 7812 3896 856 3820 3822 mx3_x2
xsubckt_8003_mx3_x2 1 0 8848 7812 3896 858 3826 3828 mx3_x2
xsubckt_7612_ao22_x2 0 7905 1 607 594 368 ao22_x2
xsubckt_6790_ao22_x2 0 8504 1 1111 710 712 ao22_x2
xsubckt_6591_oa22_x2 0 2055 1 7631 2056 711 oa22_x2
xsubckt_6268_o2_x2 0 2371 1 739 710 o2_x2
xsubckt_6156_oa22_x2 0 2481 1 40 1741 197 oa22_x2
xsubckt_5808_o2_x2 0 2818 1 1192 710 o2_x2
xsubckt_5359_o2_x2 0 3161 1 3162 7690 o2_x2
xsubckt_5339_o2_x2 0 3180 1 3181 3182 o2_x2
xsubckt_4647_ao22_x2 0 3756 1 1795 3760 40 ao22_x2
xsubckt_4535_nand2_x0 1 0 3770 3780 3796 nand2_x0
xsubckt_4393_mx3_x2 1 0 9866 3782 3896 979 3805 3807 mx3_x2
xsubckt_4391_mx3_x2 1 0 9868 3782 3896 981 3811 3813 mx3_x2
xsubckt_4260_mx2_x2 0 9989 1 3791 3892 903 mx2_x2
xsubckt_3916_nor2_x0 1 0 4066 209 681 nor2_x0
xsubckt_3025_oa22_x2 0 4941 1 5048 5001 5002 oa22_x2
xsubckt_1017_nand3_x0 1 0 6803 6804 6805 6806 nand3_x0
xsubckt_905_oa22_x2 0 6910 1 1737 6919 6911 oa22_x2
xsubckt_1449_o2_x2 0 6392 1 181 210 o2_x2
xsubckt_1752_oa22_x2 0 1924 1 6111 6092 6095 oa22_x2
xsubckt_2378_o2_x2 0 5576 1 5577 704 o2_x2
xsubckt_9557_sff1_x4 1 1872 0 8916 1215 sff1_x4
xsubckt_9034_sff1_x4 1 1872 0 9392 188 sff1_x4
xsubckt_8657_sff1_x4 1 1872 0 9736 1072 sff1_x4
xsubckt_8223_mx2_x2 0 8610 1 7797 3886 1617 mx2_x2
xsubckt_8221_mx2_x2 0 8612 1 7797 3892 1639 mx2_x2
xsubckt_8009_mx3_x2 1 0 8842 7812 3896 852 3808 3810 mx3_x2
xsubckt_7686_ao22_x2 0 7844 1 7652 7954 7845 ao22_x2
xsubckt_7089_nand2_x0 1 0 8212 8213 8220 nand2_x0
xsubckt_6640_nand2_x0 1 0 2007 2008 2012 nand2_x0
xsubckt_6550_nand2_x0 1 0 2095 2096 712 nand2_x0
xsubckt_6119_nand2_x0 1 0 2516 2517 2519 nand2_x0
xsubckt_4395_mx3_x2 1 0 9864 3782 3896 976 3799 3801 mx3_x2
xsubckt_4266_mx2_x2 0 9983 1 3791 3870 875 mx2_x2
xsubckt_4264_mx2_x2 0 9985 1 3791 3878 877 mx2_x2
xsubckt_4262_mx2_x2 0 9987 1 3791 3886 881 mx2_x2
xsubckt_3653_nand2_x0 1 0 4324 4325 7219 nand2_x0
xsubckt_3120_mx3_x2 1 0 4847 707 705 4848 1603 739 mx3_x2
xsubckt_2593_o2_x2 0 5364 1 5371 5377 o2_x2
xsubckt_1067_ao22_x2 0 6756 1 6797 6775 6777 ao22_x2
xsubckt_1458_nand2_x0 1 0 6383 6385 6390 nand2_x0
xsubckt_1489_o2_x2 0 6352 1 192 222 o2_x2
xsubckt_1621_nxr2_x1 6220 1 0 195 225 nxr2_x1
xsubckt_1709_nxr2_x1 6132 1 0 423 207 nxr2_x1
xsubckt_2324_ao22_x2 0 5629 1 5633 5632 5630 ao22_x2
xsubckt_9465_sff1_x4 1 1872 0 9001 1395 sff1_x4
xsubckt_8229_mx2_x2 0 8604 1 7797 3862 1609 mx2_x2
xsubckt_8227_mx2_x2 0 8606 1 7797 3870 1611 mx2_x2
xsubckt_8225_mx2_x2 0 8608 1 7797 3878 1613 mx2_x2
xsubckt_7823_mx3_x2 1 0 9018 7822 3897 1413 3856 3857 mx3_x2
xsubckt_7821_mx3_x2 1 0 9020 7822 3897 1385 3863 3864 mx3_x2
xsubckt_7252_nand2_x0 1 0 9306 8131 8132 nand2_x0
xsubckt_6064_oa22_x2 0 2570 1 2571 2584 2728 oa22_x2
xsubckt_5812_ao22_x2 0 2814 1 2819 2817 2815 ao22_x2
xsubckt_5147_nand2_x0 1 0 9534 3358 3369 nand2_x0
xsubckt_4268_mx2_x2 0 9981 1 3791 3862 873 mx2_x2
xsubckt_813_oa22_x2 0 6998 1 7000 7013 7791 oa22_x2
xsubckt_1885_nand3_x0 1 0 5971 5972 5973 5974 nand3_x0
xsubckt_9822_sff1_x4 1 1872 0 8654 1656 sff1_x4
xsubckt_8565_sff1_x4 1 1872 0 9828 1020 sff1_x4
xsubckt_7829_mx3_x2 1 0 9012 7822 3896 1407 3838 3840 mx3_x2
xsubckt_7827_mx3_x2 1 0 9014 7822 3896 1409 3844 3846 mx3_x2
xsubckt_7825_mx3_x2 1 0 9016 7822 3896 1411 3850 3852 mx3_x2
xsubckt_7594_ao22_x2 0 9180 1 7956 7920 7922 ao22_x2
xsubckt_7395_oa22_x2 0 9272 1 8028 8025 8027 oa22_x2
xsubckt_6102_nand2_x0 1 0 2533 2534 7631 nand2_x0
xsubckt_3479_mx3_x2 1 0 4495 707 705 4496 955 1115 mx3_x2
xsubckt_3132_ao22_x2 0 10072 1 4836 4877 4885 ao22_x2
xsubckt_887_oa22_x2 0 6928 1 6947 6945 6946 oa22_x2
xsubckt_2323_nand2_x0 1 0 5630 5631 7631 nand2_x0
xsubckt_9373_sff1_x4 1 1872 0 9088 348 sff1_x4
xsubckt_8922_sff1_x4 1 1872 0 9471 1836 sff1_x4
xsubckt_8189_mx2_x2 0 8642 1 7799 3886 1233 mx2_x2
xsubckt_8187_mx2_x2 0 8644 1 7799 3892 1255 mx2_x2
xsubckt_7785_mx3_x2 1 0 9052 7826 3897 1381 3856 3857 mx3_x2
xsubckt_7783_mx3_x2 1 0 9054 7826 3897 1353 3863 3864 mx3_x2
xsubckt_7781_mx3_x2 1 0 9056 7826 3897 1355 3871 3872 mx3_x2
xsubckt_7221_a4_x2 0 8154 1 8155 9093 9095 9094 a4_x2
xsubckt_7072_nand2_x0 1 0 8228 8229 8231 nand2_x0
xsubckt_7047_mx3_x2 1 0 8253 712 710 8255 7380 7382 mx3_x2
xsubckt_6809_nand2_x0 1 0 8486 8487 8490 nand2_x0
xsubckt_4820_ao22_x2 0 3620 1 1774 3622 40 ao22_x2
xsubckt_3693_mx2_x2 0 4284 1 7218 4285 4290 mx2_x2
xsubckt_3632_nand3_x0 1 0 4344 4345 4370 5586 nand3_x0
xsubckt_3364_oa22_x2 0 4608 1 766 7217 4609 oa22_x2
xsubckt_3040_ao22_x2 0 4926 1 4931 4929 4927 ao22_x2
xsubckt_2987_oa22_x2 0 4978 1 4979 705 7219 oa22_x2
xsubckt_2944_mx3_x2 1 0 5020 707 705 5021 1606 742 mx3_x2
xsubckt_2942_mx3_x2 1 0 5022 707 705 5023 1542 1670 mx3_x2
xsubckt_1133_oa22_x2 0 163 1 1740 6703 6693 oa22_x2
xsubckt_757_nand2_x0 1 0 7051 7686 229 nand2_x0
xsubckt_692_nor3_x0 1 0 7109 41 43 42 nor3_x0
xsubckt_542_inv_x0 1 0 417 7249 inv_x0
xsubckt_540_inv_x0 1 0 423 7251 inv_x0
xsubckt_151_inv_x0 1 0 397 7640 inv_x0
xsubckt_1351_nand2_x0 1 0 6486 588 1786 nand2_x0
xsubckt_1575_nor2_x0 1 0 6266 6267 6269 nor2_x0
xsubckt_2160_mx3_x2 1 0 473 7162 5754 224 102 134 mx3_x2
xsubckt_2162_mx3_x2 1 0 471 7162 5754 222 100 132 mx3_x2
xsubckt_2422_mx2_x2 0 5533 1 705 1703 1575 mx2_x2
xsubckt_9818_sff1_x4 1 1872 0 8658 1661 sff1_x4
xsubckt_9730_sff1_x4 1 1872 0 8746 756 sff1_x4
xsubckt_8996_sff1_x4 1 1872 0 9429 505 sff1_x4
xsubckt_8473_sff1_x4 1 1872 0 9920 1516 sff1_x4
xsubckt_7789_mx3_x2 1 0 9048 7826 3896 1377 3844 3846 mx3_x2
xsubckt_7787_mx3_x2 1 0 9050 7826 3896 1379 3850 3852 mx3_x2
xsubckt_7689_nand2_x0 1 0 7842 8018 361 nand2_x0
xsubckt_7068_nand3_x0 1 0 8232 8233 8247 7620 nand3_x0
xsubckt_6125_mx3_x2 1 0 2511 712 710 2512 1254 1414 mx3_x2
xsubckt_6123_mx3_x2 1 0 2513 712 710 2514 966 1126 mx3_x2
xsubckt_5837_nand2_x0 1 0 2789 2790 2791 nand2_x0
xsubckt_4085_a4_x2 0 3900 1 3902 7168 523 7213 a4_x2
xsubckt_2819_mx2_x2 0 5143 1 705 1418 1258 mx2_x2
xsubckt_2817_mx2_x2 0 5145 1 705 1130 970 mx2_x2
xsubckt_2771_mx2_x2 0 5190 1 7217 7561 7563 mx2_x2
xsubckt_920_nand2_x0 1 0 6896 587 1774 nand2_x0
xsubckt_640_nor2_x0 1 0 7155 577 578 nor2_x0
xsubckt_548_inv_x0 1 0 195 7243 inv_x0
xsubckt_546_inv_x0 1 0 193 7245 inv_x0
xsubckt_544_inv_x0 1 0 419 7247 inv_x0
xsubckt_157_inv_x0 1 0 382 7634 inv_x0
xsubckt_155_inv_x0 1 0 383 7636 inv_x0
xsubckt_153_inv_x0 1 0 386 7638 inv_x0
xsubckt_1968_nand2_x0 1 0 5896 6112 6378 nand2_x0
xsubckt_2001_a3_x2 1 5865 0 5866 5867 5868 a3_x2
xsubckt_2033_mx2_x2 0 5836 1 7788 5837 5839 mx2_x2
xsubckt_2053_nand2_x0 1 0 5818 5819 6152 nand2_x0
xsubckt_2143_nand2_x0 1 0 422 5756 5768 nand2_x0
xsubckt_2164_mx3_x2 1 0 469 7162 5754 220 98 130 mx3_x2
xsubckt_2166_mx3_x2 1 0 466 7162 5754 217 95 127 mx3_x2
xsubckt_2168_mx3_x2 1 0 464 7162 5754 215 93 125 mx3_x2
xsubckt_2228_ao22_x2 0 5723 1 7631 5724 7620 ao22_x2
xsubckt_2357_nor3_x0 1 0 5597 5598 5600 7103 nor3_x0
xsubckt_2424_mx2_x2 0 5531 1 7217 7600 7602 mx2_x2
xsubckt_9369_sff1_x4 1 1872 0 9092 354 sff1_x4
xsubckt_9281_sff1_x4 1 1872 0 9180 688 sff1_x4
xsubckt_8918_sff1_x4 1 1872 0 9475 1841 sff1_x4
xsubckt_8830_sff1_x4 1 1872 0 9563 74 sff1_x4
xsubckt_7299_oa22_x2 0 9294 1 8133 8101 8099 oa22_x2
xsubckt_6863_mx3_x2 1 0 8433 712 710 8434 1589 725 mx3_x2
xsubckt_6861_mx3_x2 1 0 8435 712 710 8436 1525 1653 mx3_x2
xsubckt_6732_mx2_x2 0 8561 1 710 1368 856 mx2_x2
xsubckt_6730_mx2_x2 0 8563 1 710 760 1624 mx2_x2
xsubckt_6539_nand2_x0 1 0 2106 2107 2108 nand2_x0
xsubckt_6167_ao22_x2 0 2470 1 933 710 712 ao22_x2
xsubckt_5871_nor2_x0 1 0 2756 2757 2759 nor2_x0
xsubckt_4816_ao22_x2 0 3623 1 1775 3625 40 ao22_x2
xsubckt_2775_mx2_x2 0 5186 1 707 5187 5188 mx2_x2
xsubckt_2773_mx2_x2 0 5188 1 7217 7564 7566 mx2_x2
xsubckt_916_nand3_x0 1 0 6900 6901 308 230 nand3_x0
xsubckt_159_inv_x0 1 0 381 7632 inv_x0
xsubckt_1240_ao22_x2 0 6591 1 6592 6596 7038 ao22_x2
xsubckt_1433_nxr2_x1 6408 1 0 179 208 nxr2_x1
xsubckt_1763_ao22_x2 0 6082 1 6136 6091 6134 ao22_x2
xsubckt_1921_oa22_x2 0 5939 1 190 220 574 oa22_x2
xsubckt_2380_mx2_x2 0 5574 1 705 1448 1288 mx2_x2
xsubckt_9726_sff1_x4 1 1872 0 8750 760 sff1_x4
xsubckt_9203_sff1_x4 1 1872 0 9255 656 sff1_x4
xsubckt_8826_sff1_x4 1 1872 0 9567 48 sff1_x4
xsubckt_8469_sff1_x4 1 1872 0 9924 1532 sff1_x4
xsubckt_8381_sff1_x4 1 1872 0 10004 1566 sff1_x4
xsubckt_7656_oa22_x2 0 7868 1 644 7679 700 oa22_x2
xsubckt_7027_a2_x2 0 8273 1 8274 7625 a2_x2
xsubckt_6734_mx2_x2 0 8559 1 712 8560 8561 mx2_x2
xsubckt_6690_mx2_x2 0 1958 1 710 1721 889 mx2_x2
xsubckt_6359_nand2_x0 1 0 2282 1409 7625 nand2_x0
xsubckt_6083_mx3_x2 1 0 2552 712 710 2553 7539 7541 mx3_x2
xsubckt_5571_a3_x2 1 9476 0 2992 2993 40 a3_x2
xsubckt_5190_a2_x2 0 3318 1 3507 668 a2_x2
xsubckt_5150_a2_x2 0 3355 1 3516 670 a2_x2
xsubckt_4916_a3_x2 1 9575 0 3548 3550 40 a3_x2
xsubckt_4868_a4_x2 0 3584 1 1764 1763 1761 1760 a4_x2
xsubckt_3701_nand4_x0 1 0 4276 5604 532 7689 61 nand4_x0
xsubckt_2779_mx2_x2 0 5182 1 705 1163 1035 mx2_x2
xsubckt_2590_xr2_x1 5367 0 1 207 679 xr2_x1
xsubckt_963_mx2_x2 0 6855 1 7685 7025 7678 mx2_x2
xsubckt_669_o2_x2 0 7126 1 230 229 o2_x2
xsubckt_590_o2_x2 0 7201 1 344 343 o2_x2
xsubckt_1260_a2_x2 0 6572 1 214 1739 a2_x2
xsubckt_1995_oa22_x2 0 5871 1 5872 5874 6403 oa22_x2
xsubckt_9277_sff1_x4 1 1872 0 9184 684 sff1_x4
xsubckt_8303_sff1_x4 1 1872 0 10082 207 sff1_x4
xsubckt_7087_a2_x2 0 8214 1 8215 708 a2_x2
xsubckt_6694_mx2_x2 0 1954 1 712 1955 1956 mx2_x2
xsubckt_6692_mx2_x2 0 1956 1 710 1401 1241 mx2_x2
xsubckt_6647_a2_x2 0 2000 1 7455 710 a2_x2
xsubckt_6269_nand2_x0 1 0 2370 2371 712 nand2_x0
xsubckt_5814_mx2_x2 0 2812 1 7625 7617 7619 mx2_x2
xsubckt_5810_mx2_x2 0 2816 1 710 1224 1096 mx2_x2
xsubckt_5698_ao22_x2 0 2893 1 1423 707 7217 ao22_x2
xsubckt_5463_nand4_x0 1 0 3070 3079 1815 1826 1837 nand4_x0
xsubckt_5209_nand2_x0 1 0 9529 3301 3311 nand2_x0
xsubckt_5030_mx2_x2 0 3462 1 5753 3807 119 mx2_x2
xsubckt_4976_a3_x2 1 3503 0 40 70 7780 a3_x2
xsubckt_4956_a3_x2 1 3518 0 40 75 7780 a3_x2
xsubckt_4936_a3_x2 1 3533 0 40 50 7780 a3_x2
xsubckt_4853_nor3_x0 1 0 9590 3596 3597 7702 nor3_x0
xsubckt_4724_ao22_x2 0 3694 1 1798 3695 40 ao22_x2
xsubckt_4086_a2_x2 0 3899 1 3900 3907 a2_x2
xsubckt_4002_oa22_x2 0 3981 1 3982 705 7219 oa22_x2
xsubckt_3793_a3_x2 1 4186 0 4187 4192 7215 a3_x2
xsubckt_3535_nand2_x0 1 0 4440 4441 7219 nand2_x0
xsubckt_3372_a2_x2 0 4600 1 4601 703 a2_x2
xsubckt_1534_a2_x2 0 6307 1 175 199 a2_x2
xsubckt_1951_nand2_x0 1 0 5911 6114 6368 nand2_x0
xsubckt_9634_sff1_x4 1 1872 0 8839 848 sff1_x4
xsubckt_9111_sff1_x4 1 1872 0 1916 1884 sff1_x4
xsubckt_8734_sff1_x4 1 1872 0 9659 1285 sff1_x4
xsubckt_8377_sff1_x4 1 1872 0 10008 1570 sff1_x4
xsubckt_7314_nand2_x0 1 0 8087 8095 8130 nand2_x0
xsubckt_7129_oa22_x2 0 8174 1 1740 7789 518 oa22_x2
xsubckt_6179_nand2_x0 1 0 2458 2459 7631 nand2_x0
xsubckt_6089_nand2_x0 1 0 2546 2547 2548 nand2_x0
xsubckt_5933_a2_x2 0 2698 1 2699 7628 a2_x2
xsubckt_5034_mx2_x2 0 3459 1 5753 3804 118 mx2_x2
xsubckt_4996_a3_x2 1 3488 0 40 64 7780 a3_x2
xsubckt_4770_a2_x2 0 9610 1 3659 3660 a2_x2
xsubckt_4630_mx3_x2 1 0 9646 3765 3896 1271 3817 3819 mx3_x2
xsubckt_3176_oa22_x2 0 4792 1 4803 4810 703 oa22_x2
xsubckt_2777_a2_x2 0 5184 1 5185 7215 a2_x2
xsubckt_2737_a2_x2 0 5223 1 5224 7217 a2_x2
xsubckt_1327_xr2_x1 6509 0 1 682 57 xr2_x1
xsubckt_1667_ao22_x2 0 6174 1 6177 6180 6370 ao22_x2
xsubckt_1947_nand3_x0 1 0 5915 5917 5919 6366 nand3_x0
xsubckt_2044_ao22_x2 0 5826 1 574 5829 5827 ao22_x2
xsubckt_9542_sff1_x4 1 1872 0 8931 1212 sff1_x4
xsubckt_9185_sff1_x4 1 1872 0 9273 590 sff1_x4
xsubckt_9107_sff1_x4 1 1872 0 1920 1888 sff1_x4
xsubckt_8200_mx3_x2 1 0 8631 7800 3896 1250 3847 3849 mx3_x2
xsubckt_6340_ao22_x2 0 2301 1 7497 7625 712 ao22_x2
xsubckt_6301_o2_x2 0 2339 1 2340 711 o2_x2
xsubckt_5993_a2_x2 0 2640 1 2641 708 a2_x2
xsubckt_5202_nxr2_x1 3307 1 0 3505 667 nxr2_x1
xsubckt_5038_mx2_x2 0 3456 1 5753 3801 116 mx2_x2
xsubckt_4876_o4_x2 0 3577 1 3581 3605 3631 7719 o4_x2
xsubckt_4636_mx3_x2 1 0 9640 3765 3896 1264 3799 3801 mx3_x2
xsubckt_4634_mx3_x2 1 0 9642 3765 3896 1267 3805 3807 mx3_x2
xsubckt_4632_mx3_x2 1 0 9644 3765 3896 1269 3811 3813 mx3_x2
xsubckt_4503_mx2_x2 0 9765 1 3772 3892 1095 mx2_x2
xsubckt_4243_mx3_x2 1 0 10003 3795 3896 1565 3832 3834 mx3_x2
xsubckt_4241_mx3_x2 1 0 10005 3795 3896 1567 3838 3840 mx3_x2
xsubckt_3975_nor2_x0 1 0 4008 208 680 nor2_x0
xsubckt_3732_ao22_x2 0 4246 1 823 7217 7219 ao22_x2
xsubckt_2797_a2_x2 0 5164 1 5165 5173 a2_x2
xsubckt_2473_nand2_x0 1 0 5482 7153 7686 nand2_x0
xsubckt_1899_oa22_x2 0 5959 1 5960 6194 7788 oa22_x2
xsubckt_8642_sff1_x4 1 1872 0 9751 1089 sff1_x4
xsubckt_8206_mx3_x2 1 0 8625 7800 3896 1243 3829 3831 mx3_x2
xsubckt_8204_mx3_x2 1 0 8627 7800 3896 1246 3835 3837 mx3_x2
xsubckt_8202_mx3_x2 1 0 8629 7800 3896 1248 3841 3843 mx3_x2
xsubckt_6186_o2_x2 0 2451 1 741 710 o2_x2
xsubckt_5297_o2_x2 0 3219 1 3220 3230 o2_x2
xsubckt_4985_mx3_x2 1 0 3496 5754 518 7766 7326 7327 mx3_x2
xsubckt_4981_mx3_x2 1 0 3499 5754 518 7765 7328 7329 mx3_x2
xsubckt_4864_oa22_x2 0 3587 1 3591 1763 1761 oa22_x2
xsubckt_4592_mx3_x2 1 0 9681 3768 3896 1114 3826 3828 mx3_x2
xsubckt_4590_mx3_x2 1 0 9683 3768 3896 1117 3832 3834 mx3_x2
xsubckt_4507_mx2_x2 0 9761 1 3772 3878 1069 mx2_x2
xsubckt_4505_mx2_x2 0 9763 1 3772 3886 1073 mx2_x2
xsubckt_4249_mx3_x2 1 0 9997 3795 3896 1558 3814 3816 mx3_x2
xsubckt_4247_mx3_x2 1 0 9999 3795 3896 1560 3820 3822 mx3_x2
xsubckt_4245_mx3_x2 1 0 10001 3795 3896 1562 3826 3828 mx3_x2
xsubckt_4116_mx2_x2 0 3875 1 518 80 1876 mx2_x2
xsubckt_4112_mx2_x2 0 3878 1 3896 3879 3880 mx2_x2
xsubckt_3175_nand2_x0 1 0 4793 4794 7218 nand2_x0
xsubckt_1052_ao22_x2 0 6770 1 6776 6773 6774 ao22_x2
xsubckt_73_inv_x0 1 0 1764 7718 inv_x0
xsubckt_71_inv_x0 1 0 1757 7720 inv_x0
xsubckt_1289_xr2_x1 6545 0 1 684 59 xr2_x1
xsubckt_1376_oa22_x2 0 6462 1 6719 6471 6463 oa22_x2
xsubckt_1562_o2_x2 0 6279 1 445 229 o2_x2
xsubckt_2110_oa22_x2 0 5771 1 7685 308 7243 oa22_x2
xsubckt_2296_o2_x2 0 297 1 5657 5660 o2_x2
xsubckt_9538_sff1_x4 1 1872 0 10100 1738 sff1_x4
xsubckt_9450_sff1_x4 1 1872 0 9016 1411 sff1_x4
xsubckt_9093_sff1_x4 1 1872 0 1905 1873 sff1_x4
xsubckt_9015_sff1_x4 1 1872 0 9411 445 sff1_x4
xsubckt_8208_mx3_x2 1 0 8623 7800 3896 1241 3823 3825 mx3_x2
xsubckt_8164_mx3_x2 1 0 8665 7802 3896 1668 3853 3855 mx3_x2
xsubckt_8162_mx3_x2 1 0 8667 7802 3897 1670 3859 3860 mx3_x2
xsubckt_8160_mx3_x2 1 0 8669 7802 3897 1642 3867 3868 mx3_x2
xsubckt_6779_nand2_x0 1 0 8515 8516 712 nand2_x0
xsubckt_5987_nand2_x0 1 0 2646 2647 2650 nand2_x0
xsubckt_5959_ao22_x2 0 2673 1 2674 2676 7613 ao22_x2
xsubckt_5809_nand2_x0 1 0 2817 2818 712 nand2_x0
xsubckt_5102_nand2_x0 1 0 3399 3529 7654 nand2_x0
xsubckt_4989_mx3_x2 1 0 3493 5754 518 7767 7324 7325 mx3_x2
xsubckt_4598_mx3_x2 1 0 9675 3768 3896 1108 3808 3810 mx3_x2
xsubckt_4596_mx3_x2 1 0 9677 3768 3896 1110 3814 3816 mx3_x2
xsubckt_4594_mx3_x2 1 0 9679 3768 3896 1112 3820 3822 mx3_x2
xsubckt_4118_mx2_x2 0 10048 1 3898 3874 1580 mx2_x2
xsubckt_625_nand4_x0 1 0 7166 573 1738 40 7790 nand4_x0
xsubckt_79_inv_x0 1 0 1775 7712 inv_x0
xsubckt_77_inv_x0 1 0 1768 7714 inv_x0
xsubckt_75_inv_x0 1 0 1766 7716 inv_x0
xsubckt_1284_oa22_x2 0 6550 1 6568 6563 6567 oa22_x2
xsubckt_2025_nand2_x0 1 0 5843 6114 6395 nand2_x0
xsubckt_2383_ao22_x2 0 5571 1 1256 7217 5572 ao22_x2
xsubckt_9089_sff1_x4 1 1872 0 1909 1877 sff1_x4
xsubckt_8638_sff1_x4 1 1872 0 9755 1093 sff1_x4
xsubckt_8550_sff1_x4 1 1872 0 9843 1501 sff1_x4
xsubckt_8168_mx3_x2 1 0 8661 7802 3896 1664 3841 3843 mx3_x2
xsubckt_8166_mx3_x2 1 0 8663 7802 3896 1666 3847 3849 mx3_x2
xsubckt_6767_ao22_x2 0 8527 1 7625 1303 8528 ao22_x2
xsubckt_5897_nand2_x0 1 0 2733 7134 420 nand2_x0
xsubckt_4469_mx2_x2 0 9797 1 3774 3892 1479 mx2_x2
xsubckt_3334_nand3_x0 1 0 4637 4638 4788 7104 nand3_x0
xsubckt_3327_mx3_x2 1 0 4644 704 7215 4645 4652 4654 mx3_x2
xsubckt_1143_nand2_x0 1 0 6683 1827 589 nand2_x0
xsubckt_1048_ao22_x2 0 6774 1 6775 6797 1740 ao22_x2
xsubckt_1206_oa22_x2 0 158 1 6635 6634 6624 oa22_x2
xsubckt_1641_oa22_x2 0 6200 1 6214 6211 6201 oa22_x2
xsubckt_9881_sff1_x4 1 1872 0 8595 1630 sff1_x4
xsubckt_9446_sff1_x4 1 1872 0 9020 1385 sff1_x4
xsubckt_7502_mx2_x2 0 9208 1 7985 430 325 mx2_x2
xsubckt_7500_mx2_x2 0 9210 1 7985 432 327 mx2_x2
xsubckt_5092_nxr2_x1 3408 1 0 3409 3410 nxr2_x1
xsubckt_4747_nand2_x0 1 0 3677 3678 7709 nand2_x0
xsubckt_4643_nand4_x0 1 0 3759 644 1807 1806 1742 nand4_x0
xsubckt_3938_mx2_x2 0 4044 1 705 1459 1299 mx2_x2
xsubckt_3678_mx3_x2 1 0 4299 707 705 4300 856 1368 mx3_x2
xsubckt_3152_mx2_x2 0 4816 1 706 4817 4819 mx2_x2
xsubckt_3150_mx2_x2 0 4818 1 705 770 1634 mx2_x2
xsubckt_1405_ao22_x2 0 6435 1 6436 6440 7038 ao22_x2
xsubckt_2291_ao22_x2 0 5661 1 646 7675 7684 ao22_x2
xsubckt_9803_sff1_x4 1 1872 0 8673 1646 sff1_x4
xsubckt_8981_sff1_x4 1 1872 0 9444 490 sff1_x4
xsubckt_8903_sff1_x4 1 1872 0 9490 1857 sff1_x4
xsubckt_8546_sff1_x4 1 1872 0 9847 1505 sff1_x4
xsubckt_7851_mx2_x2 0 8992 1 7819 3878 1165 mx2_x2
xsubckt_7508_mx2_x2 0 9202 1 7985 424 319 mx2_x2
xsubckt_7506_mx2_x2 0 9204 1 7985 426 321 mx2_x2
xsubckt_7504_mx2_x2 0 9206 1 7985 428 323 mx2_x2
xsubckt_7052_ao22_x2 0 8248 1 8249 8250 708 ao22_x2
xsubckt_6152_ao22_x2 0 2484 1 2485 2500 2729 ao22_x2
xsubckt_4192_nxr2_x1 3817 1 0 3821 60 nxr2_x1
xsubckt_3868_oa22_x2 0 4113 1 4164 4159 4163 oa22_x2
xsubckt_3156_mx2_x2 0 4812 1 705 1730 898 mx2_x2
xsubckt_1114_oa22_x2 0 6710 1 6721 6719 6711 oa22_x2
xsubckt_647_nor4_x0 1 0 7148 611 574 584 572 nor4_x0
xsubckt_350_inv_x0 1 0 921 7441 inv_x0
xsubckt_9877_sff1_x4 1 1872 0 8599 1634 sff1_x4
xsubckt_9354_sff1_x4 1 1872 0 9107 1051 sff1_x4
xsubckt_8977_sff1_x4 1 1872 0 147 84 sff1_x4
xsubckt_6672_nand2_x0 1 0 1976 1977 7631 nand2_x0
xsubckt_6582_nand2_x0 1 0 2064 2065 7631 nand2_x0
xsubckt_6324_mx3_x2 1 0 2316 712 710 2317 866 1378 mx3_x2
xsubckt_4257_a4_x2 0 3792 1 3793 3901 3903 3906 a4_x2
xsubckt_3898_mx2_x2 0 4083 1 7219 4084 4085 mx2_x2
xsubckt_3896_mx2_x2 0 4085 1 705 1492 1332 mx2_x2
xsubckt_2880_oa22_x2 0 5083 1 1417 7217 5084 oa22_x2
xsubckt_2644_ao22_x2 0 5314 1 5326 5322 5315 ao22_x2
xsubckt_2627_mx2_x2 0 5331 1 705 1006 814 mx2_x2
xsubckt_2625_nand2_x0 1 0 5333 5334 7218 nand2_x0
xsubckt_2623_mx2_x2 0 5335 1 705 1710 878 mx2_x2
xsubckt_1050_a3_x2 1 6772 0 6776 6794 6796 a3_x2
xsubckt_352_inv_x0 1 0 793 7439 inv_x0
xsubckt_354_inv_x0 1 0 1593 7437 inv_x0
xsubckt_356_inv_x0 1 0 1529 7435 inv_x0
xsubckt_9711_sff1_x4 1 1872 0 8765 746 sff1_x4
xsubckt_8811_sff1_x4 1 1872 0 9582 1756 sff1_x4
xsubckt_8454_sff1_x4 1 1872 0 9939 733 sff1_x4
xsubckt_7641_oa22_x2 0 7881 1 644 7679 698 oa22_x2
xsubckt_6931_mx2_x2 0 8366 1 7625 7392 7394 mx2_x2
xsubckt_6280_mx3_x2 1 0 2359 712 710 2360 867 1379 mx3_x2
xsubckt_5410_oa22_x2 0 3114 1 3463 3466 7672 oa22_x2
xsubckt_4188_nxr2_x1 3820 1 0 3824 7742 nxr2_x1
xsubckt_4091_a3_x2 1 3894 0 3895 517 7785 a3_x2
xsubckt_3901_ao22_x2 0 4080 1 4081 4089 7218 ao22_x2
xsubckt_2976_mx2_x2 0 4989 1 705 1701 1573 mx2_x2
xsubckt_1029_nor2_x0 1 0 6792 6793 7791 nor2_x0
xsubckt_722_o2_x2 0 7081 1 532 534 o2_x2
xsubckt_358_inv_x0 1 0 1656 7433 inv_x0
xsubckt_1221_ao22_x2 0 6609 1 6610 6614 7038 ao22_x2
xsubckt_1653_nand2_x0 1 0 6188 7225 219 nand2_x0
xsubckt_1980_oa22_x2 0 5885 1 6332 6198 6167 oa22_x2
xsubckt_2190_mx2_x2 0 10095 1 5752 9075 649 mx2_x2
xsubckt_2192_mx2_x2 0 10094 1 5752 9074 648 mx2_x2
xsubckt_2236_mx2_x2 0 5715 1 710 924 796 mx2_x2
xsubckt_2445_nand2_x0 1 0 5510 5511 706 nand2_x0
xsubckt_9785_sff1_x4 1 1872 0 8691 1694 sff1_x4
xsubckt_9707_sff1_x4 1 1872 0 8769 750 sff1_x4
xsubckt_9262_sff1_x4 1 1872 0 9199 306 sff1_x4
xsubckt_8885_sff1_x4 1 1872 0 9508 1848 sff1_x4
xsubckt_8362_sff1_x4 1 1872 0 10023 1583 sff1_x4
xsubckt_8281_buf_x1 1 0 1731 8728 buf_x1
xsubckt_7180_a2_x2 0 9343 1 8159 40 a2_x2
xsubckt_6505_a2_x2 0 2139 1 7491 710 a2_x2
xsubckt_6224_nand2_x0 1 0 2414 2415 711 nand2_x0
xsubckt_5079_a3_x2 1 3420 0 3534 3537 3540 a3_x2
xsubckt_5013_mx3_x2 1 0 3475 5754 518 7773 7312 7313 mx3_x2
xsubckt_3035_a2_x2 0 4931 1 705 7516 a2_x2
xsubckt_969_nand2_x0 1 0 6849 1835 589 nand2_x0
xsubckt_782_o2_x2 0 7027 1 7028 7031 o2_x2
xsubckt_684_oa22_x2 0 10097 1 308 7169 7114 oa22_x2
xsubckt_1412_a2_x2 0 6429 1 177 205 a2_x2
xsubckt_1649_nand3_x0 1 0 6192 6353 7222 222 nand3_x0
xsubckt_2146_a2_x2 0 5754 1 517 526 a2_x2
xsubckt_2194_mx2_x2 0 10093 1 5752 9073 647 mx2_x2
xsubckt_2196_mx2_x2 0 10092 1 5752 9072 646 mx2_x2
xsubckt_2198_mx2_x2 0 10091 1 5752 9071 664 mx2_x2
xsubckt_9693_sff1_x4 1 1872 0 8783 793 sff1_x4
xsubckt_9258_sff1_x4 1 1872 0 9203 320 sff1_x4
xsubckt_8807_sff1_x4 1 1872 0 9586 1760 sff1_x4
xsubckt_8285_buf_x1 1 0 1727 8724 buf_x1
xsubckt_8283_buf_x1 1 0 1729 8726 buf_x1
xsubckt_7533_nand3_x0 1 0 7966 7168 657 7791 nand3_x0
xsubckt_7454_a2_x2 0 8001 1 8014 8144 a2_x2
xsubckt_7434_a2_x2 0 8015 1 8016 8019 a2_x2
xsubckt_6579_ao22_x2 0 2067 1 7628 2072 708 ao22_x2
xsubckt_6159_mx2_x2 0 2478 1 710 1445 1285 mx2_x2
xsubckt_6157_mx2_x2 0 2480 1 710 1413 1253 mx2_x2
xsubckt_6044_nand2_x0 1 0 2590 2591 712 nand2_x0
xsubckt_5568_a3_x2 1 2994 0 2999 1842 1843 a3_x2
xsubckt_5017_mx3_x2 1 0 3472 5754 518 7774 7310 7311 mx3_x2
xsubckt_4699_a3_x2 1 3716 0 1762 1751 1746 a3_x2
xsubckt_3329_a2_x2 0 4642 1 4643 4657 a2_x2
xsubckt_3290_a2_x2 0 10069 1 4681 4730 a2_x2
xsubckt_2810_a2_x2 0 5152 1 200 672 a2_x2
xsubckt_2717_nor2_x0 1 0 5243 5244 706 nor2_x0
xsubckt_883_ao22_x2 0 6931 1 6932 6936 7038 ao22_x2
xsubckt_879_nand2_x0 1 0 6935 587 1776 nand2_x0
xsubckt_1488_nxr2_x1 6353 1 0 191 221 nxr2_x1
xsubckt_2381_a2_x2 0 5573 1 5574 7219 a2_x2
xsubckt_9615_sff1_x4 1 1872 0 8858 869 sff1_x4
xsubckt_9170_sff1_x4 1 1872 0 9288 608 sff1_x4
xsubckt_8793_sff1_x4 1 1872 0 9600 1776 sff1_x4
xsubckt_8358_sff1_x4 1 1872 0 10027 1588 sff1_x4
xsubckt_8289_buf_x1 1 0 1722 8720 buf_x1
xsubckt_8287_buf_x1 1 0 1725 8722 buf_x1
xsubckt_6899_mx2_x2 0 8398 1 712 1556 1524 mx2_x2
xsubckt_5891_a2_x2 0 2737 1 7134 434 a2_x2
xsubckt_5248_nand3_x0 1 0 3265 40 130 7780 nand3_x0
xsubckt_4727_a2_x2 0 9620 1 3693 3694 a2_x2
xsubckt_3606_oa22_x2 0 4370 1 4371 4382 704 oa22_x2
xsubckt_2675_a2_x2 0 5284 1 5285 7216 a2_x2
xsubckt_2460_ao22_x2 0 5495 1 7599 7218 705 ao22_x2
xsubckt_1293_nand2_x0 1 0 6541 588 1789 nand2_x0
xsubckt_9689_sff1_x4 1 1872 0 8787 798 sff1_x4
xsubckt_9166_sff1_x4 1 1872 0 9292 581 sff1_x4
xsubckt_8715_sff1_x4 1 1872 0 9678 1111 sff1_x4
xsubckt_6914_nand2_x0 1 0 8383 8384 8388 nand2_x0
xsubckt_6203_nand3_x0 1 0 2434 2435 2460 2729 nand3_x0
xsubckt_4442_mx3_x2 1 0 9822 3777 3897 1002 3867 3868 mx3_x2
xsubckt_4012_nand2_x0 1 0 3971 3972 3990 nand2_x0
xsubckt_3592_oa22_x2 0 4384 1 7219 4385 703 oa22_x2
xsubckt_2653_nxr2_x1 5306 1 0 203 675 nxr2_x1
xsubckt_862_nand2_x0 1 0 6951 1841 589 nand2_x0
xsubckt_1225_o2_x2 0 157 1 6606 6616 o2_x2
xsubckt_1480_xr2_x1 6361 0 1 188 217 xr2_x1
xsubckt_9523_sff1_x4 1 1872 0 8943 953 sff1_x4
xsubckt_9000_sff1_x4 1 1872 0 9425 500 sff1_x4
xsubckt_8789_sff1_x4 1 1872 0 9604 1780 sff1_x4
xsubckt_8012_mx3_x2 1 0 8839 7812 3896 848 3799 3801 mx3_x2
xsubckt_8010_mx3_x2 1 0 8841 7812 3896 851 3805 3807 mx3_x2
xsubckt_4448_mx3_x2 1 0 9816 3777 3896 1026 3847 3849 mx3_x2
xsubckt_4446_mx3_x2 1 0 9818 3777 3896 1028 3853 3855 mx3_x2
xsubckt_4444_mx3_x2 1 0 9820 3777 3897 1030 3859 3860 mx3_x2
xsubckt_3747_nand2_x0 1 0 4231 4232 7218 nand2_x0
xsubckt_3532_o2_x2 0 4443 1 705 730 o2_x2
xsubckt_3337_o2_x2 0 4634 1 4635 4642 o2_x2
xsubckt_1093_xr2_x1 6731 0 1 695 70 xr2_x1
xsubckt_1265_o2_x2 0 6568 1 685 60 o2_x2
xsubckt_1357_oa22_x2 0 6480 1 6719 6489 6481 oa22_x2
xsubckt_1440_o2_x2 0 6401 1 184 213 o2_x2
xsubckt_2428_o2_x2 0 5527 1 5528 707 o2_x2
xsubckt_9597_sff1_x4 1 1872 0 8876 918 sff1_x4
xsubckt_9519_sff1_x4 1 1872 0 8947 958 sff1_x4
xsubckt_9074_sff1_x4 1 1872 0 9352 1303 sff1_x4
xsubckt_8623_sff1_x4 1 1872 0 9770 1459 sff1_x4
xsubckt_6644_nand2_x0 1 0 2003 2004 7631 nand2_x0
xsubckt_6554_nand2_x0 1 0 2091 2092 7628 nand2_x0
xsubckt_2813_ao22_x2 0 5149 1 5206 5205 5204 ao22_x2
xsubckt_2468_o2_x2 0 5487 1 701 229 o2_x2
xsubckt_682_nand2_x0 1 0 7115 7116 7192 nand2_x0
xsubckt_651_a4_x2 0 7144 1 7145 7146 7147 7148 a4_x2
xsubckt_621_ao22_x2 0 7170 1 7193 7171 7172 ao22_x2
xsubckt_592_nand2_x0 1 0 7199 342 345 nand2_x0
xsubckt_1774_o2_x2 0 6072 1 6073 6261 o2_x2
xsubckt_1805_nand2_x0 1 0 6044 6045 6246 nand2_x0
xsubckt_1893_nand2_x0 1 0 5964 6112 6352 nand2_x0
xsubckt_9431_sff1_x4 1 1872 0 9035 1363 sff1_x4
xsubckt_8697_sff1_x4 1 1872 0 9696 1100 sff1_x4
xsubckt_8619_sff1_x4 1 1872 0 9774 1463 sff1_x4
xsubckt_7830_mx3_x2 1 0 9011 7822 3896 1406 3835 3837 mx3_x2
xsubckt_7560_ao22_x2 0 7945 1 607 594 355 ao22_x2
xsubckt_5417_ao22_x2 0 3107 1 3108 3110 3118 ao22_x2
xsubckt_3906_nand3_x0 1 0 4075 4076 4224 7104 nand3_x0
xsubckt_3621_ao22_x2 0 4355 1 7219 4356 703 ao22_x2
xsubckt_3477_nand2_x0 1 0 4497 4498 7216 nand2_x0
xsubckt_2721_ao22_x2 0 5239 1 1228 7217 5240 ao22_x2
xsubckt_2507_nand2_x0 1 0 5449 7217 1116 nand2_x0
xsubckt_853_oa22_x2 0 6960 1 7050 7053 7291 oa22_x2
xsubckt_1625_nand2_x0 1 0 6216 6220 6317 nand2_x0
xsubckt_1788_oa22_x2 0 6059 1 6258 6259 7788 oa22_x2
xsubckt_9427_sff1_x4 1 1872 0 9039 1367 sff1_x4
xsubckt_8531_sff1_x4 1 1872 0 9862 1512 sff1_x4
xsubckt_8192_mx2_x2 0 8639 1 7799 3874 1228 mx2_x2
xsubckt_8190_mx2_x2 0 8641 1 7799 3882 1230 mx2_x2
xsubckt_7836_mx3_x2 1 0 9005 7822 3896 1399 3817 3819 mx3_x2
xsubckt_7834_mx3_x2 1 0 9007 7822 3896 1401 3823 3825 mx3_x2
xsubckt_7832_mx3_x2 1 0 9009 7822 3896 1403 3829 3831 mx3_x2
xsubckt_7703_mx2_x2 0 9160 1 8139 7831 701 mx2_x2
xsubckt_7256_nand2_x0 1 0 9305 8128 8129 nand2_x0
xsubckt_6984_oa22_x2 0 8314 1 708 8315 8321 oa22_x2
xsubckt_6225_ao22_x2 0 2413 1 740 710 712 ao22_x2
xsubckt_5668_nand3_x0 1 0 2921 2927 1812 1813 nand3_x0
xsubckt_3730_nand2_x0 1 0 4248 4249 7218 nand2_x0
xsubckt_3640_nand2_x0 1 0 4336 4337 4344 nand2_x0
xsubckt_3486_mx3_x2 1 0 4488 707 705 4489 1595 731 mx3_x2
xsubckt_3484_mx3_x2 1 0 4490 707 705 4491 1531 1659 mx3_x2
xsubckt_3006_mx2_x2 0 4959 1 705 1445 1285 mx2_x2
xsubckt_2604_mx3_x2 1 0 5354 707 705 5355 1518 1646 mx3_x2
xsubckt_200_inv_x0 1 0 753 7591 inv_x0
xsubckt_1535_nand2_x0 1 0 6306 175 199 nand2_x0
xsubckt_9862_sff1_x4 1 1872 0 8614 1231 sff1_x4
xsubckt_8962_sff1_x4 1 1872 0 164 101 sff1_x4
xsubckt_8527_sff1_x4 1 1872 0 9866 979 sff1_x4
xsubckt_7838_mx3_x2 1 0 9003 7822 3896 1397 3811 3813 mx3_x2
xsubckt_7792_mx3_x2 1 0 9045 7826 3896 1374 3835 3837 mx3_x2
xsubckt_7790_mx3_x2 1 0 9047 7826 3896 1376 3841 3843 mx3_x2
xsubckt_7709_mx2_x2 0 9156 1 7829 3886 1329 mx2_x2
xsubckt_7707_mx2_x2 0 9158 1 7829 3892 1351 mx2_x2
xsubckt_7556_ao22_x2 0 7948 1 607 594 353 ao22_x2
xsubckt_7357_oa22_x2 0 9280 1 8076 8055 8056 oa22_x2
xsubckt_6891_nand3_x0 1 0 8405 8406 8413 7613 nand3_x0
xsubckt_5325_ao22_x2 0 3193 1 600 3194 644 ao22_x2
xsubckt_4089_nand2_x0 1 0 3896 517 7785 nand2_x0
xsubckt_3636_nand3_x0 1 0 4340 4341 4533 5699 nand3_x0
xsubckt_3297_nand2_x0 1 0 4674 4677 4725 nand2_x0
xsubckt_3283_nand4_x0 1 0 4687 5604 532 7689 69 nand4_x0
xsubckt_2820_mx2_x2 0 5142 1 707 5143 5144 mx2_x2
xsubckt_2606_mx3_x2 1 0 5352 707 705 5353 1582 718 mx3_x2
xsubckt_2562_mx3_x2 1 0 5395 707 705 5396 7588 7590 mx3_x2
xsubckt_2518_oa22_x2 0 5438 1 1436 7217 5439 oa22_x2
xsubckt_206_inv_x0 1 0 1265 7585 inv_x0
xsubckt_204_inv_x0 1 0 1425 7587 inv_x0
xsubckt_202_inv_x0 1 0 1617 7589 inv_x0
xsubckt_9858_sff1_x4 1 1872 0 8618 1236 sff1_x4
xsubckt_9770_sff1_x4 1 1872 0 8706 1681 sff1_x4
xsubckt_9335_sff1_x4 1 1872 0 9126 1063 sff1_x4
xsubckt_7798_mx3_x2 1 0 9039 7826 3896 1367 3817 3819 mx3_x2
xsubckt_7796_mx3_x2 1 0 9041 7826 3896 1369 3823 3825 mx3_x2
xsubckt_7794_mx3_x2 1 0 9043 7826 3896 1371 3829 3831 mx3_x2
xsubckt_7274_mx2_x2 0 8114 1 7199 7645 7659 mx2_x2
xsubckt_7270_mx2_x2 0 8117 1 7199 7644 7661 mx2_x2
xsubckt_6814_oa22_x2 0 8481 1 7625 1142 8482 oa22_x2
xsubckt_5992_oa22_x2 0 2641 1 7625 1131 2642 oa22_x2
xsubckt_5399_ao22_x2 0 3124 1 644 3462 7168 ao22_x2
xsubckt_3960_ao22_x2 0 4022 1 4023 4030 706 ao22_x2
xsubckt_2826_mx2_x2 0 5136 1 7217 7551 7553 mx2_x2
xsubckt_966_a2_x2 0 6852 1 7143 1808 a2_x2
xsubckt_960_ao22_x2 0 6858 1 6862 6888 1740 ao22_x2
xsubckt_555_inv_x0 1 0 178 7236 inv_x0
xsubckt_553_inv_x0 1 0 176 7238 inv_x0
xsubckt_551_inv_x0 1 0 198 7240 inv_x0
xsubckt_208_inv_x0 1 0 1137 7583 inv_x0
xsubckt_164_inv_x0 1 0 840 7627 inv_x0
xsubckt_162_inv_x0 1 0 936 7629 inv_x0
xsubckt_160_inv_x0 1 0 712 7631 inv_x0
xsubckt_1565_nxr2_x1 6276 1 0 445 229 nxr2_x1
xsubckt_2057_nand2_x0 1 0 5814 6114 6423 nand2_x0
xsubckt_2147_nand2_x0 1 0 5753 517 526 nand2_x0
xsubckt_2171_mx3_x2 1 0 461 7162 5754 212 90 122 mx3_x2
xsubckt_2173_mx3_x2 1 0 459 7162 5754 210 88 120 mx3_x2
xsubckt_2175_mx3_x2 1 0 457 7162 5754 208 86 118 mx3_x2
xsubckt_2433_mx2_x2 0 5522 1 7217 7605 7609 mx2_x2
xsubckt_8958_sff1_x4 1 1872 0 168 105 sff1_x4
xsubckt_8870_sff1_x4 1 1872 0 9523 127 sff1_x4
xsubckt_8435_sff1_x4 1 1872 0 9958 744 sff1_x4
xsubckt_7276_mx2_x2 0 8113 1 7199 7646 7658 mx2_x2
xsubckt_5601_a3_x2 1 2970 0 2975 1832 1833 a3_x2
xsubckt_5200_a2_x2 0 3309 1 3504 667 a2_x2
xsubckt_4855_nand4_x0 1 0 3594 1768 1767 1766 1765 nand4_x0
xsubckt_2861_oa22_x2 0 5102 1 5150 5149 5103 oa22_x2
xsubckt_2782_mx2_x2 0 5179 1 705 1483 1323 mx2_x2
xsubckt_2780_mx2_x2 0 5181 1 705 1195 1067 mx2_x2
xsubckt_559_inv_x0 1 0 182 7232 inv_x0
xsubckt_557_inv_x0 1 0 180 7234 inv_x0
xsubckt_168_inv_x0 1 0 1672 7623 inv_x0
xsubckt_166_inv_x0 1 0 710 7625 inv_x0
xsubckt_1175_nand2_x0 1 0 6653 6654 6719 nand2_x0
xsubckt_1692_nand3_x0 1 0 6149 6426 7236 206 nand3_x0
xsubckt_2177_mx3_x2 1 0 454 7162 5754 205 83 115 mx3_x2
xsubckt_9766_sff1_x4 1 1872 0 8710 1711 sff1_x4
xsubckt_9243_sff1_x4 1 1872 0 9218 336 sff1_x4
xsubckt_6743_mx2_x2 0 8550 1 710 1496 1336 mx2_x2
xsubckt_6741_mx2_x2 0 8552 1 710 1464 1304 mx2_x2
xsubckt_6403_a2_x2 0 2239 1 7494 710 a2_x2
xsubckt_6354_mx2_x2 0 2287 1 710 929 801 mx2_x2
xsubckt_6009_mx2_x2 0 2624 1 710 1483 1323 mx2_x2
xsubckt_5240_a2_x2 0 3272 1 3495 651 a2_x2
xsubckt_5045_a2_x2 0 3451 1 3544 648 a2_x2
xsubckt_4732_a3_x2 1 3688 0 1798 1797 1796 a3_x2
xsubckt_3012_nand2_x0 1 0 4953 7152 7272 nand2_x0
xsubckt_2784_mx2_x2 0 5177 1 7217 7557 7559 mx2_x2
xsubckt_886_o3_x2 0 144 1 6929 6930 6942 o3_x2
xsubckt_1202_ao22_x2 0 6627 1 6628 6632 7038 ao22_x2
xsubckt_1330_a2_x2 0 6506 1 7143 1851 a2_x2
xsubckt_2130_nand2_x0 1 0 5762 7044 184 nand2_x0
xsubckt_2393_mx2_x2 0 5561 1 707 904 872 mx2_x2
xsubckt_2395_mx2_x2 0 5559 1 705 5560 5561 mx2_x2
xsubckt_2397_mx2_x2 0 5557 1 707 776 744 mx2_x2
xsubckt_9600_sff1_x4 1 1872 0 8873 915 sff1_x4
xsubckt_8866_sff1_x4 1 1872 0 9527 132 sff1_x4
xsubckt_8343_sff1_x4 1 1872 0 10042 1604 sff1_x4
xsubckt_7352_a2_x2 0 8058 1 8138 582 a2_x2
xsubckt_7177_a2_x2 0 9344 1 8161 40 a2_x2
xsubckt_6995_ao22_x2 0 8304 1 709 8305 708 ao22_x2
xsubckt_6356_mx2_x2 0 2285 1 710 1025 833 mx2_x2
xsubckt_6173_nand3_x0 1 0 2464 2465 2466 7613 nand3_x0
xsubckt_5821_mx2_x2 0 2805 1 7625 7622 7624 mx2_x2
xsubckt_5554_a2_x2 0 3004 1 3007 1846 a2_x2
xsubckt_5280_a2_x2 0 3235 1 3252 3486 a2_x2
xsubckt_4893_nor3_x0 1 0 3564 3567 3631 7721 nor3_x0
xsubckt_4042_oa22_x2 0 3942 1 3943 3946 704 oa22_x2
xsubckt_2533_ao22_x2 0 5423 1 5539 5485 5488 ao22_x2
xsubckt_864_ao22_x2 0 6949 1 6950 6954 7038 ao22_x2
xsubckt_1334_nand3_x0 1 0 6502 6503 6504 6505 nand3_x0
xsubckt_1624_a2_x2 0 6217 1 6220 6317 a2_x2
xsubckt_1957_oa22_x2 0 5906 1 6361 5927 5907 oa22_x2
xsubckt_2084_a2_x2 0 5792 1 5793 5794 a2_x2
xsubckt_2399_mx2_x2 0 5555 1 7216 5556 5559 mx2_x2
xsubckt_9674_sff1_x4 1 1872 0 8802 785 sff1_x4
xsubckt_9239_sff1_x4 1 1872 0 9222 310 sff1_x4
xsubckt_9151_sff1_x4 1 1872 0 9307 606 sff1_x4
xsubckt_8700_sff1_x4 1 1872 0 9693 1097 sff1_x4
xsubckt_8339_sff1_x4 1 1872 0 10046 1578 sff1_x4
xsubckt_7646_a2_x2 0 9171 1 7877 7881 a2_x2
xsubckt_7318_nand2_x0 1 0 9289 8085 8086 nand2_x0
xsubckt_6777_a2_x2 0 8517 1 7421 710 a2_x2
xsubckt_5896_oa22_x2 0 9409 1 5662 2786 2734 oa22_x2
xsubckt_5818_oa22_x2 0 2808 1 2809 2820 7613 oa22_x2
xsubckt_4919_a2_x2 0 9574 1 3546 3547 a2_x2
xsubckt_4880_a2_x2 0 9584 1 3575 3576 a2_x2
xsubckt_4860_a2_x2 0 9589 1 3590 3592 a2_x2
xsubckt_4762_nand2_x0 1 0 3664 3667 1789 nand2_x0
xsubckt_4685_a2_x2 0 3727 1 1805 1804 a2_x2
xsubckt_4665_a2_x2 0 9631 1 3743 3744 a2_x2
xsubckt_4645_a2_x2 0 9636 1 3758 3759 a2_x2
xsubckt_1154_nand3_x0 1 0 6673 6674 6675 1740 nand3_x0
xsubckt_1684_a2_x2 0 6157 1 6158 6159 a2_x2
xsubckt_2365_o4_x2 0 5589 1 532 1739 1738 1737 o4_x2
xsubckt_8774_sff1_x4 1 1872 0 9619 1797 sff1_x4
xsubckt_7383_nor4_x0 1 0 8035 369 368 367 366 nor4_x0
xsubckt_6468_ao22_x2 0 2175 1 534 532 693 ao22_x2
xsubckt_6346_nand2_x0 1 0 2295 1121 7625 nand2_x0
xsubckt_5868_a2_x2 0 2759 1 2760 7625 a2_x2
xsubckt_5829_mx2_x2 0 2797 1 710 744 1608 mx2_x2
xsubckt_5730_oa22_x2 0 2861 1 7179 2913 2862 oa22_x2
xsubckt_5540_nand4_x0 1 0 3014 3023 1851 1852 1853 nand4_x0
xsubckt_4672_nand2_x0 1 0 3737 3739 1745 nand2_x0
xsubckt_4250_mx3_x2 1 0 9996 3795 3896 1557 3811 3813 mx3_x2
xsubckt_3359_nand2_x0 1 0 4613 4614 4621 nand2_x0
xsubckt_2906_nand3_x0 1 0 5057 5058 5212 7104 nand3_x0
xsubckt_9582_sff1_x4 1 1872 0 8891 934 sff1_x4
xsubckt_9504_sff1_x4 1 1872 0 8962 945 sff1_x4
xsubckt_9147_sff1_x4 1 1872 0 9311 1135 sff1_x4
xsubckt_8682_sff1_x4 1 1872 0 9711 1432 sff1_x4
xsubckt_8213_mx3_x2 1 0 8618 7800 3896 1236 3808 3810 mx3_x2
xsubckt_8211_mx3_x2 1 0 8620 7800 3896 1238 3814 3816 mx3_x2
xsubckt_7048_nand2_x0 1 0 8252 8253 711 nand2_x0
xsubckt_6302_ao22_x2 0 2338 1 7628 2343 708 ao22_x2
xsubckt_6166_nand2_x0 1 0 2471 7526 710 nand2_x0
xsubckt_5374_nand2_x0 1 0 9517 3148 3158 nand2_x0
xsubckt_5367_o2_x2 0 3154 1 3155 7690 o2_x2
xsubckt_5238_nxr2_x1 3274 1 0 3281 3495 nxr2_x1
xsubckt_4254_mx3_x2 1 0 9992 3795 3896 1552 3799 3801 mx3_x2
xsubckt_4252_mx3_x2 1 0 9994 3795 3896 1555 3805 3807 mx3_x2
xsubckt_4121_mx2_x2 0 3871 1 518 79 1875 mx2_x2
xsubckt_2640_nand2_x0 1 0 5318 7152 7279 nand2_x0
xsubckt_80_inv_x0 1 0 1777 7711 inv_x0
xsubckt_1338_oa22_x2 0 6498 1 6719 6507 6499 oa22_x2
xsubckt_1417_o2_x2 0 6424 1 178 206 o2_x2
xsubckt_1632_o2_x2 0 6209 1 194 224 o2_x2
xsubckt_9578_sff1_x4 1 1872 0 8895 908 sff1_x4
xsubckt_9055_sff1_x4 1 1872 0 9371 1293 sff1_x4
xsubckt_8604_sff1_x4 1 1872 0 9789 1449 sff1_x4
xsubckt_8217_mx3_x2 1 0 8614 7800 3896 1231 3797 3798 mx3_x2
xsubckt_8215_mx3_x2 1 0 8616 7800 3896 1234 3802 3804 mx3_x2
xsubckt_8171_mx3_x2 1 0 8658 7802 3896 1661 3832 3834 mx3_x2
xsubckt_5999_ao22_x2 0 2634 1 712 2635 7613 ao22_x2
xsubckt_5284_nand2_x0 1 0 9523 3232 3242 nand2_x0
xsubckt_4472_mx2_x2 0 9794 1 3774 3882 1454 mx2_x2
xsubckt_4470_mx2_x2 0 9796 1 3774 3890 1468 mx2_x2
xsubckt_4127_mx2_x2 0 3866 1 3896 3867 3868 mx2_x2
xsubckt_3696_nand3_x0 1 0 4281 4282 4301 5586 nand3_x0
xsubckt_926_oa22_x2 0 6890 1 1737 6899 6891 oa22_x2
xsubckt_86_inv_x0 1 0 1795 7705 inv_x0
xsubckt_84_inv_x0 1 0 1797 7707 inv_x0
xsubckt_82_inv_x0 1 0 1791 7709 inv_x0
xsubckt_1237_nand2_x0 1 0 6594 1821 589 nand2_x0
xsubckt_1477_o2_x2 0 6364 1 188 217 o2_x2
xsubckt_1497_o2_x2 0 6344 1 189 219 o2_x2
xsubckt_1672_o2_x2 0 6169 1 6170 6174 o2_x2
xsubckt_1773_oa22_x2 0 6073 1 7246 204 7788 oa22_x2
xsubckt_2297_nand2_x0 1 0 5656 7110 41 nand2_x0
xsubckt_9490_sff1_x4 1 1872 0 8976 1178 sff1_x4
xsubckt_9412_sff1_x4 1 1872 0 9054 1353 sff1_x4
xsubckt_8678_sff1_x4 1 1872 0 9715 1437 sff1_x4
xsubckt_8590_sff1_x4 1 1872 0 9803 1012 sff1_x4
xsubckt_8175_mx3_x2 1 0 8654 7802 3896 1656 3820 3822 mx3_x2
xsubckt_8173_mx3_x2 1 0 8656 7802 3896 1658 3826 3828 mx3_x2
xsubckt_4474_mx2_x2 0 9792 1 3774 3874 1452 mx2_x2
xsubckt_3729_mx3_x2 1 0 4249 707 705 4250 855 1367 mx3_x2
xsubckt_3205_mx2_x2 0 4764 1 706 4765 4768 mx2_x2
xsubckt_3203_mx2_x2 0 4766 1 705 1729 897 mx2_x2
xsubckt_3201_mx2_x2 0 4768 1 707 4769 4770 mx2_x2
xsubckt_1147_nand2_x0 1 0 6679 6680 6681 nand2_x0
xsubckt_88_inv_x0 1 0 343 7703 inv_x0
xsubckt_1246_oa22_x2 0 6586 1 6604 6599 6603 oa22_x2
xsubckt_2345_ao22_x2 0 5609 1 481 7193 1738 ao22_x2
xsubckt_9486_sff1_x4 1 1872 0 8980 1183 sff1_x4
xsubckt_8512_sff1_x4 1 1872 0 9881 995 sff1_x4
xsubckt_8179_mx3_x2 1 0 8650 7802 3896 1652 3808 3810 mx3_x2
xsubckt_8177_mx3_x2 1 0 8652 7802 3896 1654 3814 3816 mx3_x2
xsubckt_6007_oa22_x2 0 2626 1 2627 2630 2633 oa22_x2
xsubckt_5529_nand4_x0 1 0 3022 3031 1854 1855 1856 nand4_x0
xsubckt_3945_mx2_x2 0 4037 1 705 1139 979 mx2_x2
xsubckt_2538_nxr2_x1 5418 1 0 5419 5423 nxr2_x1
xsubckt_716_nand2_x0 1 0 7086 644 7690 nand2_x0
xsubckt_401_inv_x0 1 0 1523 7390 inv_x0
xsubckt_1880_ao22_x2 0 5976 1 5977 5978 5979 ao22_x2
xsubckt_2102_nand2_x0 1 0 5778 420 308 nand2_x0
xsubckt_9843_sff1_x4 1 1872 0 8633 1252 sff1_x4
xsubckt_9408_sff1_x4 1 1872 0 9058 1357 sff1_x4
xsubckt_9320_sff1_x4 1 1872 0 9141 1342 sff1_x4
xsubckt_8586_sff1_x4 1 1872 0 9807 1016 sff1_x4
xsubckt_8508_sff1_x4 1 1872 0 9885 969 sff1_x4
xsubckt_7991_mx3_x2 1 0 8860 7812 3897 841 3863 3864 mx3_x2
xsubckt_5974_nand2_x0 1 0 2658 2659 7620 nand2_x0
xsubckt_3949_mx2_x2 0 4033 1 705 1395 1235 mx2_x2
xsubckt_3687_mx3_x2 1 0 4290 707 705 4291 7425 7428 mx3_x2
xsubckt_3556_mx2_x2 0 4419 1 705 1498 1338 mx2_x2
xsubckt_3510_ao22_x2 0 4465 1 7444 7217 7218 ao22_x2
xsubckt_3024_xr2_x1 4942 0 1 226 698 xr2_x1
xsubckt_2809_nand2_x0 1 0 10078 5153 5154 nand2_x0
xsubckt_403_inv_x0 1 0 1331 7388 inv_x0
xsubckt_405_inv_x0 1 0 912 7386 inv_x0
xsubckt_407_inv_x0 1 0 784 7384 inv_x0
xsubckt_1189_nxr2_x1 6640 1 0 689 64 nxr2_x1
xsubckt_1927_nand2_x0 1 0 5933 6112 6344 nand2_x0
xsubckt_2012_nand2_x0 1 0 5855 6114 6388 nand2_x0
xsubckt_9839_sff1_x4 1 1872 0 8637 1226 sff1_x4
xsubckt_9394_sff1_x4 1 1872 0 9067 356 sff1_x4
xsubckt_8943_sff1_x4 1 1872 0 9450 1813 sff1_x4
xsubckt_8420_sff1_x4 1 1872 0 9973 895 sff1_x4
xsubckt_7997_mx3_x2 1 0 8854 7812 3896 865 3844 3846 mx3_x2
xsubckt_7995_mx3_x2 1 0 8856 7812 3896 867 3850 3852 mx3_x2
xsubckt_7993_mx3_x2 1 0 8858 7812 3897 869 3856 3857 mx3_x2
xsubckt_7811_nand2_x0 1 0 7821 3780 3787 nand2_x0
xsubckt_7614_nor2_x0 1 0 7903 7904 7905 nor2_x0
xsubckt_6637_ao22_x2 0 2010 1 7625 1306 2011 ao22_x2
xsubckt_6350_oa22_x2 0 2291 1 7625 1153 2292 oa22_x2
xsubckt_6331_mx3_x2 1 0 2309 7628 7613 2310 2316 2318 mx3_x2
xsubckt_5349_nand4_x0 1 0 3171 3174 3217 3224 3225 nand4_x0
xsubckt_5173_nand3_x0 1 0 3334 40 136 7780 nand3_x0
xsubckt_4841_ao22_x2 0 3604 1 3605 3631 7714 ao22_x2
xsubckt_4734_nand2_x0 1 0 3686 3687 40 nand2_x0
xsubckt_3742_oa22_x2 0 4236 1 1431 7217 4237 oa22_x2
xsubckt_3599_nand2_x0 1 0 4377 4378 4380 nand2_x0
xsubckt_2629_nand2_x0 1 0 5329 5330 706 nand2_x0
xsubckt_884_a2_x2 0 6930 1 203 1739 a2_x2
xsubckt_361_inv_x0 1 0 1528 7430 inv_x0
xsubckt_363_inv_x0 1 0 1464 7428 inv_x0
xsubckt_409_inv_x0 1 0 1392 7382 inv_x0
xsubckt_1747_nand2_x0 1 0 6096 6112 6284 nand2_x0
xsubckt_9751_sff1_x4 1 1872 0 8725 1728 sff1_x4
xsubckt_9316_sff1_x4 1 1872 0 9145 1346 sff1_x4
xsubckt_8939_sff1_x4 1 1872 0 9454 1818 sff1_x4
xsubckt_8494_sff1_x4 1 1872 0 9899 1524 sff1_x4
xsubckt_8416_sff1_x4 1 1872 0 9977 899 sff1_x4
xsubckt_7999_mx3_x2 1 0 8852 7812 3896 863 3838 3840 mx3_x2
xsubckt_7681_oa22_x2 0 7848 1 644 7679 675 oa22_x2
xsubckt_7479_mx2_x2 0 9231 1 7986 341 446 mx2_x2
xsubckt_5451_a4_x2 0 3079 1 1848 1859 1870 1871 a4_x2
xsubckt_5214_ao22_x2 0 3296 1 600 3297 644 ao22_x2
xsubckt_5015_oa22_x2 0 9550 1 7168 3474 3476 oa22_x2
xsubckt_3017_a3_x2 1 4948 0 4949 4950 4952 a3_x2
xsubckt_2981_mx2_x2 0 4984 1 706 1093 997 mx2_x2
xsubckt_365_inv_x0 1 0 1336 7426 inv_x0
xsubckt_367_inv_x0 1 0 1240 7424 inv_x0
xsubckt_369_inv_x0 1 0 919 7422 inv_x0
xsubckt_1657_nand2_x0 1 0 6184 6186 6188 nand2_x0
xsubckt_2243_mx2_x2 0 5708 1 710 1372 860 mx2_x2
xsubckt_2245_mx2_x2 0 5706 1 711 5707 5712 mx2_x2
xsubckt_9747_sff1_x4 1 1872 0 8729 1732 sff1_x4
xsubckt_8851_sff1_x4 1 1872 0 9542 139 sff1_x4
xsubckt_7230_a2_x2 0 8148 1 8149 8154 a2_x2
xsubckt_6551_mx2_x2 0 2094 1 710 765 1629 mx2_x2
xsubckt_6162_mx2_x2 0 2475 1 710 1509 1349 mx2_x2
xsubckt_5804_mx3_x2 1 0 2822 712 710 2823 968 1128 mx3_x2
xsubckt_5384_a3_x2 1 3138 0 3177 3465 3468 a3_x2
xsubckt_4650_a3_x2 1 3754 0 1806 1795 1784 a3_x2
xsubckt_3215_oa22_x2 0 4754 1 4755 705 707 oa22_x2
xsubckt_1013_a2_x2 0 6807 1 7143 1868 a2_x2
xsubckt_826_mx2_x2 0 6986 1 229 406 389 mx2_x2
xsubckt_1820_nand2_x0 1 0 6030 6116 6305 nand2_x0
xsubckt_1942_oa22_x2 0 5920 1 6360 5929 6178 oa22_x2
xsubckt_2411_a2_x2 0 5543 1 5544 5549 a2_x2
xsubckt_2449_nand2_x0 1 0 5506 5507 7218 nand2_x0
xsubckt_9298_sff1_x4 1 1872 0 9163 676 sff1_x4
xsubckt_9224_sff1_x4 1 1872 0 9237 538 sff1_x4
xsubckt_8847_sff1_x4 1 1872 0 9546 56 sff1_x4
xsubckt_8324_sff1_x4 1 1872 0 10061 213 sff1_x4
xsubckt_8292_buf_x1 1 0 1719 8717 buf_x1
xsubckt_8290_buf_x1 1 0 1721 8719 buf_x1
xsubckt_7361_nand2_x0 1 0 8052 8138 576 nand2_x0
xsubckt_7309_a2_x2 0 8091 1 8121 7661 a2_x2
xsubckt_6948_mx2_x2 0 8350 1 712 1139 1107 mx2_x2
xsubckt_6745_nand3_x0 1 0 8548 8553 8555 709 nand3_x0
xsubckt_6655_nand3_x0 1 0 1992 1993 2007 7620 nand3_x0
xsubckt_6615_a2_x2 0 2032 1 2033 7625 a2_x2
xsubckt_6164_mx2_x2 0 2473 1 710 1029 837 mx2_x2
xsubckt_6096_ao22_x2 0 2539 1 2540 2542 2543 ao22_x2
xsubckt_6048_nand2_x0 1 0 2586 2587 7628 nand2_x0
xsubckt_5237_a2_x2 0 3275 1 3281 3495 a2_x2
xsubckt_4964_a3_x2 1 3512 0 40 73 7780 a3_x2
xsubckt_4944_a3_x2 1 3527 0 40 48 7780 a3_x2
xsubckt_4924_a3_x2 1 3542 0 40 65 7780 a3_x2
xsubckt_3439_a2_x2 0 4534 1 4535 4549 a2_x2
xsubckt_3380_a2_x2 0 4592 1 4593 7219 a2_x2
xsubckt_3289_oa22_x2 0 4681 1 7179 4722 4682 oa22_x2
xsubckt_1387_nand2_x0 1 0 6452 1812 589 nand2_x0
xsubckt_1718_mx2_x2 0 6123 1 6126 601 6124 mx2_x2
xsubckt_9655_sff1_x4 1 1872 0 8821 832 sff1_x4
xsubckt_9132_sff1_x4 1 1872 0 9326 1152 sff1_x4
xsubckt_8398_sff1_x4 1 1872 0 10092 709 sff1_x4
xsubckt_8298_buf_x1 1 0 1712 8711 buf_x1
xsubckt_8296_buf_x1 1 0 1715 8713 buf_x1
xsubckt_8294_buf_x1 1 0 1717 8715 buf_x1
xsubckt_7369_a2_x2 0 8046 1 8060 8124 a2_x2
xsubckt_6976_ao22_x2 0 8322 1 710 8325 8323 ao22_x2
xsubckt_6565_nand3_x0 1 0 2080 2081 2090 709 nand3_x0
xsubckt_5076_nand2_x0 1 0 3423 3535 7651 nand2_x0
xsubckt_4984_a3_x2 1 3497 0 40 68 7780 a3_x2
xsubckt_3654_a2_x2 0 4323 1 705 7430 a2_x2
xsubckt_3492_nand2_x0 1 0 4482 7152 7262 nand2_x0
xsubckt_2491_a2_x2 0 5465 1 5466 5467 a2_x2
xsubckt_1550_nand2_x0 1 0 6291 6292 6296 nand2_x0
xsubckt_1582_a2_x2 0 6259 1 6260 6290 a2_x2
xsubckt_1640_nand2_x0 1 0 6201 6205 6325 nand2_x0
xsubckt_8755_sff1_x4 1 1872 0 9638 2 sff1_x4
xsubckt_7878_a2_x2 0 7818 1 3783 3787 a2_x2
xsubckt_7023_o2_x2 0 8276 1 8277 7134 o2_x2
xsubckt_6989_a2_x2 0 9384 1 8310 8352 a2_x2
xsubckt_6918_nand2_x0 1 0 8379 8380 7631 nand2_x0
xsubckt_4877_a2_x2 0 9585 1 3577 3579 a2_x2
xsubckt_4062_o2_x2 0 3922 1 705 1104 o2_x2
xsubckt_3398_nand3_x0 1 0 4574 4575 4736 5699 nand3_x0
xsubckt_3197_oa22_x2 0 4772 1 4777 4833 7180 oa22_x2
xsubckt_2980_a2_x2 0 4985 1 4986 7217 a2_x2
xsubckt_1041_o2_x2 0 6780 1 6781 6782 o2_x2
xsubckt_1896_a2_x2 0 5962 1 5969 6349 a2_x2
xsubckt_2204_o2_x2 0 5747 1 664 649 o2_x2
xsubckt_2351_o3_x2 0 5603 1 1739 1738 1737 o3_x2
xsubckt_9563_sff1_x4 1 1872 0 8910 1208 sff1_x4
xsubckt_9128_sff1_x4 1 1872 0 9330 1156 sff1_x4
xsubckt_9040_sff1_x4 1 1872 0 9386 182 sff1_x4
xsubckt_6738_nand2_x0 1 0 8555 8556 7631 nand2_x0
xsubckt_6154_o2_x2 0 2482 1 2483 7134 o2_x2
xsubckt_4455_mx3_x2 1 0 9809 3777 3896 1018 3826 3828 mx3_x2
xsubckt_4453_mx3_x2 1 0 9811 3777 3896 1021 3832 3834 mx3_x2
xsubckt_4451_mx3_x2 1 0 9813 3777 3896 1023 3838 3840 mx3_x2
xsubckt_3447_o2_x2 0 4526 1 4527 4534 o2_x2
xsubckt_3407_o2_x2 0 4566 1 219 691 o2_x2
xsubckt_776_nand2_x0 1 0 7033 587 1781 nand2_x0
xsubckt_1370_nand2_x0 1 0 6468 1813 589 nand2_x0
xsubckt_8663_sff1_x4 1 1872 0 9730 1422 sff1_x4
xsubckt_8027_mx3_x2 1 0 8826 7810 3897 837 3856 3857 mx3_x2
xsubckt_8025_mx3_x2 1 0 8828 7810 3897 809 3863 3864 mx3_x2
xsubckt_8023_mx3_x2 1 0 8830 7810 3897 811 3871 3872 mx3_x2
xsubckt_6357_ao22_x2 0 2284 1 712 2285 7613 ao22_x2
xsubckt_5512_nor3_x0 1 0 9492 3035 3036 7702 nor3_x0
xsubckt_5235_nand3_x0 1 0 3277 40 131 7780 nand3_x0
xsubckt_5131_nxr2_x1 3372 1 0 3390 3522 nxr2_x1
xsubckt_4885_oa22_x2 0 3570 1 7720 3571 7702 oa22_x2
xsubckt_4649_ao22_x2 0 3755 1 3759 7705 7706 ao22_x2
xsubckt_4459_mx3_x2 1 0 9805 3777 3896 1014 3814 3816 mx3_x2
xsubckt_4457_mx3_x2 1 0 9807 3777 3896 1016 3820 3822 mx3_x2
xsubckt_907_oa22_x2 0 6909 1 6928 6927 6926 oa22_x2
xsubckt_1319_oa22_x2 0 6516 1 6719 6525 6517 oa22_x2
xsubckt_1375_o2_x2 0 6463 1 6464 6465 o2_x2
xsubckt_1809_nand2_x0 1 0 6040 6114 6248 nand2_x0
xsubckt_1987_nand2_x0 1 0 5878 6114 6400 nand2_x0
xsubckt_2072_nand2_x0 1 0 1911 5801 5805 nand2_x0
xsubckt_2330_ao22_x2 0 5623 1 5624 5626 7620 ao22_x2
xsubckt_9559_sff1_x4 1 1872 0 8914 1213 sff1_x4
xsubckt_9471_sff1_x4 1 1872 0 8995 1180 sff1_x4
xsubckt_9036_sff1_x4 1 1872 0 9390 186 sff1_x4
xsubckt_8659_sff1_x4 1 1872 0 9734 1448 sff1_x4
xsubckt_8029_mx3_x2 1 0 8824 7810 3896 835 3850 3852 mx3_x2
xsubckt_6558_nand2_x0 1 0 2087 2088 7628 nand2_x0
xsubckt_5258_oa22_x2 0 3255 1 7102 3260 3256 oa22_x2
xsubckt_4870_nand4_x0 1 0 3582 3591 1763 1761 1760 nand4_x0
xsubckt_3976_o2_x2 0 4007 1 208 680 o2_x2
xsubckt_3928_mx3_x2 1 0 4054 707 705 4055 1587 723 mx3_x2
xsubckt_3880_mx3_x2 1 0 4101 704 7219 4104 4102 4103 mx3_x2
xsubckt_3142_mx3_x2 1 0 4826 707 705 4827 962 1122 mx3_x2
xsubckt_893_oa22_x2 0 6922 1 7050 7053 7286 oa22_x2
xsubckt_614_a3_x2 1 7177 0 7178 7195 40 a3_x2
xsubckt_1673_nor2_x0 1 0 6168 6169 6181 nor2_x0
xsubckt_2326_ao22_x2 0 5627 1 1358 710 712 ao22_x2
xsubckt_8571_sff1_x4 1 1872 0 9822 1002 sff1_x4
xsubckt_7843_mx3_x2 1 0 8998 7822 3896 1391 3797 3798 mx3_x2
xsubckt_7841_mx3_x2 1 0 9000 7822 3896 1394 3802 3804 mx3_x2
xsubckt_7710_mx2_x2 0 9155 1 7829 3882 1326 mx2_x2
xsubckt_7522_ao22_x2 0 7974 1 2857 2860 304 ao22_x2
xsubckt_7513_nand2_x0 1 0 7981 7160 7202 nand2_x0
xsubckt_7323_oa22_x2 0 9287 1 8105 8101 8082 oa22_x2
xsubckt_6946_oa22_x2 0 8352 1 40 1741 180 oa22_x2
xsubckt_6265_ao22_x2 0 2374 1 2375 2377 2378 ao22_x2
xsubckt_5408_nand2_x0 1 0 3116 3131 3141 nand2_x0
xsubckt_5127_nxr2_x1 3376 1 0 3523 7655 nxr2_x1
xsubckt_4034_ao22_x2 0 3950 1 706 3952 703 ao22_x2
xsubckt_3886_mx3_x2 1 0 4095 703 7216 4101 4096 4099 mx3_x2
xsubckt_3882_mx3_x2 1 0 4099 707 705 4100 948 1108 mx3_x2
xsubckt_3657_ao22_x2 0 4320 1 4321 4323 4324 ao22_x2
xsubckt_3370_oa22_x2 0 4602 1 1086 705 707 oa22_x2
xsubckt_2611_mx3_x2 1 0 5347 707 705 5348 1038 1166 mx3_x2
xsubckt_845_nand3_x0 1 0 148 6968 6976 6983 nand3_x0
xsubckt_9824_sff1_x4 1 1872 0 8652 1654 sff1_x4
xsubckt_9467_sff1_x4 1 1872 0 8999 1392 sff1_x4
xsubckt_8567_sff1_x4 1 1872 0 9826 1006 sff1_x4
xsubckt_7714_mx2_x2 0 9151 1 7829 3866 1322 mx2_x2
xsubckt_7712_mx2_x2 0 9153 1 7829 3874 1324 mx2_x2
xsubckt_7596_ao22_x2 0 7918 1 607 594 364 ao22_x2
xsubckt_6288_nand2_x0 1 0 2351 2352 7620 nand2_x0
xsubckt_5085_nor2_x0 1 0 3414 3415 3426 nor2_x0
xsubckt_3888_mx3_x2 1 0 4093 707 705 4094 852 1364 mx3_x2
xsubckt_665_nand3_x0 1 0 7130 40 76 482 nand3_x0
xsubckt_213_inv_x0 1 0 782 7578 inv_x0
xsubckt_211_inv_x0 1 0 945 7580 inv_x0
xsubckt_1531_nxr2_x1 6310 1 0 198 228 nxr2_x1
xsubckt_1702_nand2_x0 1 0 6139 446 230 nand2_x0
xsubckt_2222_mx3_x2 1 0 5729 712 710 5730 1052 1180 mx3_x2
xsubckt_9375_sff1_x4 1 1872 0 9086 346 sff1_x4
xsubckt_9301_sff1_x4 1 1872 0 9160 701 sff1_x4
xsubckt_8924_sff1_x4 1 1872 0 9469 1834 sff1_x4
xsubckt_8401_sff1_x4 1 1872 0 297 42 sff1_x4
xsubckt_7518_ao22_x2 0 7977 1 2857 2860 305 ao22_x2
xsubckt_6854_oa22_x2 0 8442 1 8443 710 7628 oa22_x2
xsubckt_6537_nand3_x0 1 0 2108 2122 2124 711 nand3_x0
xsubckt_5722_ao22_x2 0 2869 1 7109 210 1739 ao22_x2
xsubckt_5074_oa22_x2 0 3425 1 3437 3436 3435 oa22_x2
xsubckt_4135_nxr2_x1 3860 1 0 3865 7730 nxr2_x1
xsubckt_2915_oa22_x2 0 5049 1 5152 5105 5106 oa22_x2
xsubckt_2833_mx2_x2 0 5129 1 705 1450 1290 mx2_x2
xsubckt_2582_nand2_x0 1 0 5375 7153 7294 nand2_x0
xsubckt_2573_mx3_x2 1 0 5384 707 705 5385 7580 7582 mx3_x2
xsubckt_2571_mx3_x2 1 0 5386 704 7219 5387 5390 5391 mx3_x2
xsubckt_616_nor3_x0 1 0 7175 573 585 586 nor3_x0
xsubckt_562_inv_x0 1 0 185 7229 inv_x0
xsubckt_560_inv_x0 1 0 183 7231 inv_x0
xsubckt_171_inv_x0 1 0 709 7620 inv_x0
xsubckt_215_inv_x0 1 0 1454 7576 inv_x0
xsubckt_217_inv_x0 1 0 1294 7574 inv_x0
xsubckt_219_inv_x0 1 0 1485 7572 inv_x0
xsubckt_2404_nand2_x0 1 0 5550 5551 707 nand2_x0
xsubckt_2442_mx2_x2 0 5513 1 705 1415 1255 mx2_x2
xsubckt_9732_sff1_x4 1 1872 0 8744 754 sff1_x4
xsubckt_8998_sff1_x4 1 1872 0 9427 502 sff1_x4
xsubckt_8475_sff1_x4 1 1872 0 9918 1514 sff1_x4
xsubckt_6530_ao22_x2 0 2115 1 925 710 712 ao22_x2
xsubckt_6361_nand2_x0 1 0 2280 2281 2282 nand2_x0
xsubckt_6271_nand2_x0 1 0 2368 2369 7631 nand2_x0
xsubckt_6012_mx2_x2 0 2621 1 710 1355 843 mx2_x2
xsubckt_6010_mx2_x2 0 2623 1 712 2624 2625 mx2_x2
xsubckt_5048_nand2_x0 1 0 3448 648 600 nand2_x0
xsubckt_5047_a3_x2 1 3449 0 3544 7102 648 a3_x2
xsubckt_3922_ao22_x2 0 4060 1 4113 4110 4111 ao22_x2
xsubckt_3374_nand2_x0 1 0 4598 4599 4606 nand2_x0
xsubckt_3284_nand2_x0 1 0 4686 7152 7266 nand2_x0
xsubckt_2837_mx2_x2 0 5125 1 705 1354 842 mx2_x2
xsubckt_2835_mx2_x2 0 5127 1 704 5128 5131 mx2_x2
xsubckt_2665_ao22_x2 0 5294 1 1261 7217 7219 ao22_x2
xsubckt_2492_nand2_x0 1 0 5464 707 1468 nand2_x0
xsubckt_996_ao22_x2 0 6823 1 6824 6828 7038 ao22_x2
xsubckt_568_inv_x0 1 0 191 7223 inv_x0
xsubckt_566_inv_x0 1 0 189 7225 inv_x0
xsubckt_564_inv_x0 1 0 187 7227 inv_x0
xsubckt_177_inv_x0 1 0 968 7614 inv_x0
xsubckt_175_inv_x0 1 0 1320 7616 inv_x0
xsubckt_173_inv_x0 1 0 1480 7618 inv_x0
xsubckt_1179_nand2_x0 1 0 6649 587 1760 nand2_x0
xsubckt_1432_nand2_x0 1 0 6409 179 208 nand2_x0
xsubckt_1522_nand2_x0 1 0 6319 196 226 nand2_x0
xsubckt_1713_a4_x2 0 6128 1 6132 6137 6276 6281 a4_x2
xsubckt_1786_nand3_x0 1 0 6061 6062 6063 6064 nand3_x0
xsubckt_2444_mx2_x2 0 5511 1 707 5512 5513 mx2_x2
xsubckt_2446_mx2_x2 0 5509 1 705 1479 1319 mx2_x2
xsubckt_9283_sff1_x4 1 1872 0 9178 691 sff1_x4
xsubckt_8832_sff1_x4 1 1872 0 9561 72 sff1_x4
xsubckt_8116_a2_x2 0 7804 1 3790 3796 a2_x2
xsubckt_6888_nand2_x0 1 0 8408 8409 7631 nand2_x0
xsubckt_6492_mx3_x2 1 0 2152 712 710 2154 7483 7485 mx3_x2
xsubckt_6024_a2_x2 0 9405 1 2610 2653 a2_x2
xsubckt_6016_mx2_x2 0 2617 1 710 747 1611 mx2_x2
xsubckt_6014_mx2_x2 0 2619 1 710 1163 1035 mx2_x2
xsubckt_6003_nand2_x0 1 0 2630 2631 2632 nand2_x0
xsubckt_5516_a3_x2 1 9491 0 3032 3033 40 a3_x2
xsubckt_5300_nxr2_x1 3217 1 0 3481 665 nxr2_x1
xsubckt_4802_a3_x2 1 9602 0 3635 3636 40 a3_x2
xsubckt_4769_nand4_x0 1 0 3659 3667 1789 1788 1787 nand4_x0
xsubckt_3396_a4_x2 0 4576 1 5604 532 7689 67 a4_x2
xsubckt_3194_nand2_x0 1 0 4775 4776 4832 nand2_x0
xsubckt_3023_a2_x2 0 4943 1 226 698 a2_x2
xsubckt_2795_mx2_x2 0 5166 1 704 5167 5170 mx2_x2
xsubckt_2793_mx2_x2 0 5168 1 705 1707 875 mx2_x2
xsubckt_2791_mx2_x2 0 5170 1 7219 5171 5172 mx2_x2
xsubckt_830_ao22_x2 0 6982 1 7013 7000 7002 ao22_x2
xsubckt_179_inv_x0 1 0 702 7612 inv_x0
xsubckt_1400_a2_x2 0 6440 1 7143 1846 a2_x2
xsubckt_1923_oa22_x2 0 5937 1 5938 6187 7788 oa22_x2
xsubckt_2114_a2_x2 0 5768 1 5769 5770 a2_x2
xsubckt_2134_nand2_x0 1 0 5760 7044 182 nand2_x0
xsubckt_2224_nand2_x0 1 0 5727 5729 709 nand2_x0
xsubckt_2448_mx2_x2 0 5507 1 707 5508 5509 mx2_x2
xsubckt_9728_sff1_x4 1 1872 0 8748 758 sff1_x4
xsubckt_9640_sff1_x4 1 1872 0 8836 839 sff1_x4
xsubckt_9205_sff1_x4 1 1872 0 9253 654 sff1_x4
xsubckt_8828_sff1_x4 1 1872 0 9565 46 sff1_x4
xsubckt_8383_sff1_x4 1 1872 0 10002 1563 sff1_x4
xsubckt_7462_a2_x2 0 7997 1 7162 7790 a2_x2
xsubckt_7442_a2_x2 0 8009 1 8077 8127 a2_x2
xsubckt_6961_ao22_x2 0 8337 1 8338 8340 8341 ao22_x2
xsubckt_6758_mx2_x2 0 8536 1 712 1623 1591 mx2_x2
xsubckt_6756_mx2_x2 0 8538 1 712 1687 1655 mx2_x2
xsubckt_6719_a3_x2 1 8574 0 8575 1937 708 a3_x2
xsubckt_6177_nand3_x0 1 0 2460 2461 2464 7620 nand3_x0
xsubckt_5828_nand2_x0 1 0 2798 2799 2801 nand2_x0
xsubckt_5771_a3_x2 1 2852 0 2853 2854 5602 a3_x2
xsubckt_5175_a2_x2 0 3332 1 3510 669 a2_x2
xsubckt_3758_a3_x2 1 4220 0 4221 5595 5608 a3_x2
xsubckt_3631_oa22_x2 0 4345 1 4346 4359 7216 oa22_x2
xsubckt_3357_a2_x2 0 4615 1 4616 703 a2_x2
xsubckt_3083_a2_x2 0 4884 1 225 697 a2_x2
xsubckt_869_o2_x2 0 6945 1 675 50 o2_x2
xsubckt_849_o2_x2 0 6964 1 6965 6966 o2_x2
xsubckt_9279_sff1_x4 1 1872 0 9182 686 sff1_x4
xsubckt_9191_sff1_x4 1 1872 0 9267 662 sff1_x4
xsubckt_8740_sff1_x4 1 1872 0 9653 1279 sff1_x4
xsubckt_8305_sff1_x4 1 1872 0 10080 203 sff1_x4
xsubckt_6398_a2_x2 0 2244 1 7493 710 a2_x2
xsubckt_6369_mx2_x2 0 2272 1 710 1505 1345 mx2_x2
xsubckt_6087_nand3_x0 1 0 2548 2562 2564 711 nand3_x0
xsubckt_5644_a2_x2 0 9456 1 2939 2940 a2_x2
xsubckt_4882_a3_x2 1 3573 0 3606 3615 1759 a3_x2
xsubckt_4301_mx3_x2 1 0 9951 3789 3897 715 3871 3872 mx3_x2
xsubckt_3806_a2_x2 0 4173 1 7153 7262 a2_x2
xsubckt_3627_oa22_x2 0 4349 1 761 7217 4350 oa22_x2
xsubckt_3189_nor2_x0 1 0 10071 4780 4835 nor2_x0
xsubckt_821_nand2_x0 1 0 6990 218 1739 nand2_x0
xsubckt_1779_nand2_x0 1 0 6067 6114 6288 nand2_x0
xsubckt_1919_oa22_x2 0 1926 1 6111 5945 5941 oa22_x2
xsubckt_9636_sff1_x4 1 1872 0 10098 309 sff1_x4
xsubckt_9113_sff1_x4 1 1872 0 1914 1882 sff1_x4
xsubckt_8736_sff1_x4 1 1872 0 9657 1283 sff1_x4
xsubckt_8379_sff1_x4 1 1872 0 10006 1568 sff1_x4
xsubckt_7043_oa22_x2 0 8257 1 8263 8258 8259 oa22_x2
xsubckt_6867_a2_x2 0 8429 1 8432 7613 a2_x2
xsubckt_6032_o2_x2 0 2602 1 2603 711 o2_x2
xsubckt_5811_nand2_x0 1 0 2815 2816 7631 nand2_x0
xsubckt_4775_a2_x2 0 9609 1 3655 3656 a2_x2
xsubckt_4307_mx3_x2 1 0 9945 3789 3896 739 3850 3852 mx3_x2
xsubckt_4305_mx3_x2 1 0 9947 3789 3897 741 3856 3857 mx3_x2
xsubckt_4303_mx3_x2 1 0 9949 3789 3897 713 3863 3864 mx3_x2
xsubckt_3263_nand3_x0 1 0 4707 4708 4710 706 nand3_x0
xsubckt_995_nand3_x0 1 0 6824 6825 6826 6827 nand3_x0
xsubckt_2046_ao22_x2 0 5824 1 6408 5826 6111 ao22_x2
xsubckt_9187_sff1_x4 1 1872 0 9271 588 sff1_x4
xsubckt_9109_sff1_x4 1 1872 0 1918 1886 sff1_x4
xsubckt_6865_ao22_x2 0 8431 1 8442 8444 708 ao22_x2
xsubckt_6781_nand2_x0 1 0 8513 8514 7631 nand2_x0
xsubckt_4309_mx3_x2 1 0 9943 3789 3896 737 3844 3846 mx3_x2
xsubckt_1852_nand2_x0 1 0 6001 6114 6320 nand2_x0
xsubckt_9544_sff1_x4 1 1872 0 8929 1198 sff1_x4
xsubckt_9021_sff1_x4 1 1872 0 9405 417 sff1_x4
xsubckt_8644_sff1_x4 1 1872 0 9749 1087 sff1_x4
xsubckt_7673_ao22_x2 0 9166 1 7858 7855 7856 ao22_x2
xsubckt_7305_nand2_x0 1 0 9293 8094 8098 nand2_x0
xsubckt_6500_oa22_x2 0 2144 1 7492 7625 7631 oa22_x2
xsubckt_5631_nand2_x0 1 0 2948 2951 1823 nand2_x0
xsubckt_5278_nxr2_x1 3237 1 0 3238 3241 nxr2_x1
xsubckt_4269_mx3_x2 1 0 9980 3792 3897 902 3859 3860 mx3_x2
xsubckt_4136_mx2_x2 0 3859 1 518 106 1902 mx2_x2
xsubckt_4132_mx2_x2 0 3862 1 3896 3863 3864 mx2_x2
xsubckt_3659_o2_x2 0 4318 1 705 728 o2_x2
xsubckt_3619_o2_x2 0 4357 1 4358 707 o2_x2
xsubckt_93_inv_x0 1 0 1892 7698 inv_x0
xsubckt_91_inv_x0 1 0 342 7700 inv_x0
xsubckt_1527_o2_x2 0 6314 1 198 228 o2_x2
xsubckt_1722_o2_x2 0 6119 1 6120 6141 o2_x2
xsubckt_2023_nand3_x0 1 0 5845 5846 5847 6111 nand3_x0
xsubckt_9452_sff1_x4 1 1872 0 9014 1409 sff1_x4
xsubckt_9095_sff1_x4 1 1872 0 1933 1901 sff1_x4
xsubckt_9017_sff1_x4 1 1872 0 9409 423 sff1_x4
xsubckt_8185_nand2_x0 1 0 7799 3766 3787 nand2_x0
xsubckt_8182_mx3_x2 1 0 8647 7802 3896 1648 3799 3801 mx3_x2
xsubckt_8180_mx3_x2 1 0 8649 7802 3896 1651 3805 3807 mx3_x2
xsubckt_8051_mx2_x2 0 8804 1 7807 3892 807 mx2_x2
xsubckt_7125_nand2_x0 1 0 8177 7142 1741 nand2_x0
xsubckt_6940_nand3_x0 1 0 8357 8358 8367 709 nand3_x0
xsubckt_4212_nxr2_x1 3802 1 0 3806 55 nxr2_x1
xsubckt_4094_mx2_x2 0 3892 1 3896 3893 76 mx2_x2
xsubckt_4092_mx2_x2 0 10054 1 3898 3894 1608 mx2_x2
xsubckt_4090_mx2_x2 0 3895 1 518 108 1904 mx2_x2
xsubckt_3679_o2_x2 0 4298 1 4299 706 o2_x2
xsubckt_3332_nand4_x0 1 0 4639 5604 532 7689 68 nand4_x0
xsubckt_3212_mx2_x2 0 4757 1 706 1217 1153 mx2_x2
xsubckt_1051_nand3_x0 1 0 6771 6776 6794 6796 nand3_x0
xsubckt_835_nxr2_x1 6977 1 0 6978 6982 nxr2_x1
xsubckt_771_nor3_x0 1 0 7038 1739 1737 1740 nor3_x0
xsubckt_99_inv_x0 1 0 583 7692 inv_x0
xsubckt_97_inv_x0 1 0 575 7694 inv_x0
xsubckt_95_inv_x0 1 0 1737 7696 inv_x0
xsubckt_1934_ao22_x2 0 5927 1 5928 5940 6344 ao22_x2
xsubckt_8552_sff1_x4 1 1872 0 9841 1498 sff1_x4
xsubckt_8055_mx2_x2 0 8800 1 7807 3878 781 mx2_x2
xsubckt_8053_mx2_x2 0 8802 1 7807 3886 785 mx2_x2
xsubckt_7669_ao22_x2 0 7858 1 7953 8018 357 ao22_x2
xsubckt_6769_ao22_x2 0 8525 1 8526 8527 708 ao22_x2
xsubckt_5567_nor3_x0 1 0 9477 2995 2996 7702 nor3_x0
xsubckt_4098_mx2_x2 0 10052 1 3898 3890 1596 mx2_x2
xsubckt_4096_mx2_x2 0 3891 1 518 96 1892 mx2_x2
xsubckt_3950_mx2_x2 0 4032 1 7219 4033 4034 mx2_x2
xsubckt_3609_mx2_x2 0 4367 1 705 1113 953 mx2_x2
xsubckt_3607_mx2_x2 0 4369 1 705 1145 985 mx2_x2
xsubckt_3214_mx2_x2 0 4755 1 706 1089 993 mx2_x2
xsubckt_3166_nand2_x0 1 0 4802 7217 1410 nand2_x0
xsubckt_2803_nand3_x0 1 0 5158 5159 5321 5699 nand3_x0
xsubckt_898_nand2_x0 1 0 6917 588 1751 nand2_x0
xsubckt_874_oa22_x2 0 6940 1 7050 7053 7289 oa22_x2
xsubckt_653_nor4_x0 1 0 7142 587 588 589 590 nor4_x0
xsubckt_1314_nand2_x0 1 0 6521 587 1753 nand2_x0
xsubckt_2020_oa22_x2 0 5848 1 5852 5851 5849 oa22_x2
xsubckt_2055_nxr2_x1 5816 1 0 5817 6421 nxr2_x1
xsubckt_9883_sff1_x4 1 1872 0 8593 1627 sff1_x4
xsubckt_9448_sff1_x4 1 1872 0 9018 1413 sff1_x4
xsubckt_9360_sff1_x4 1 1872 0 9101 1045 sff1_x4
xsubckt_7915_mx2_x2 0 8932 1 7815 3892 1223 mx2_x2
xsubckt_7520_mx2_x2 0 7976 1 2857 7981 304 mx2_x2
xsubckt_6246_ao22_x2 0 2392 1 534 532 698 ao22_x2
xsubckt_6063_nand2_x0 1 0 2571 2572 7620 nand2_x0
xsubckt_5978_nand2_x0 1 0 2654 2655 2657 nand2_x0
xsubckt_5094_nxr2_x1 3406 1 0 3420 3531 nxr2_x1
xsubckt_4208_nxr2_x1 3805 1 0 3809 56 nxr2_x1
xsubckt_4120_nxr2_x1 3872 1 0 3877 7727 nxr2_x1
xsubckt_3956_mx2_x2 0 4026 1 705 1683 1555 mx2_x2
xsubckt_3561_mx2_x2 0 4414 1 706 4415 4416 mx2_x2
xsubckt_3505_nand3_x0 1 0 4470 4472 4520 4521 nand3_x0
xsubckt_3270_nor2_x0 1 0 4700 4701 7216 nor2_x0
xsubckt_660_a2_x2 0 7135 1 1741 40 a2_x2
xsubckt_410_inv_x0 1 0 1264 7381 inv_x0
xsubckt_412_inv_x0 1 0 1040 7379 inv_x0
xsubckt_414_inv_x0 1 0 1711 7377 inv_x0
xsubckt_2106_nand2_x0 1 0 442 5775 5778 nand2_x0
xsubckt_2451_oa22_x2 0 5504 1 1127 706 705 oa22_x2
xsubckt_9805_sff1_x4 1 1872 0 8671 1644 sff1_x4
xsubckt_8983_sff1_x4 1 1872 0 9442 488 sff1_x4
xsubckt_8905_sff1_x4 1 1872 0 9488 1855 sff1_x4
xsubckt_8548_sff1_x4 1 1872 0 9845 1503 sff1_x4
xsubckt_8460_sff1_x4 1 1872 0 9933 726 sff1_x4
xsubckt_8254_nand3_x0 1 0 7794 2 7701 40 nand3_x0
xsubckt_7919_mx2_x2 0 8928 1 7815 3878 1197 mx2_x2
xsubckt_7917_mx2_x2 0 8930 1 7815 3886 1201 mx2_x2
xsubckt_7524_mx2_x2 0 7973 1 2857 7981 303 mx2_x2
xsubckt_7480_mx2_x2 0 9230 1 7986 340 445 mx2_x2
xsubckt_6933_nand2_x0 1 0 8364 8365 7628 nand2_x0
xsubckt_5888_nand2_x0 1 0 2739 7134 445 nand2_x0
xsubckt_5606_nand4_x0 1 0 2966 2975 1831 1832 1833 nand4_x0
xsubckt_5504_oa22_x2 0 3040 1 1863 3047 1862 oa22_x2
xsubckt_4163_a4_x2 0 3839 1 3848 70 69 68 a4_x2
xsubckt_3819_xr2_x1 4161 0 1 211 683 xr2_x1
xsubckt_1134_nand2_x0 1 0 6692 693 68 nand2_x0
xsubckt_649_nor4_x0 1 0 7146 606 601 603 602 nor4_x0
xsubckt_370_inv_x0 1 0 855 7421 inv_x0
xsubckt_416_inv_x0 1 0 1007 7375 inv_x0
xsubckt_418_inv_x0 1 0 879 7373 inv_x0
xsubckt_1838_ao22_x2 0 6014 1 6015 6016 6017 ao22_x2
xsubckt_9879_sff1_x4 1 1872 0 8597 1632 sff1_x4
xsubckt_9791_sff1_x4 1 1872 0 8685 1687 sff1_x4
xsubckt_9356_sff1_x4 1 1872 0 9105 1049 sff1_x4
xsubckt_8979_sff1_x4 1 1872 0 9446 504 sff1_x4
xsubckt_7621_nand4_x0 1 0 7897 7898 7951 7957 8140 nand4_x0
xsubckt_7486_mx2_x2 0 9224 1 7986 312 417 mx2_x2
xsubckt_7484_mx2_x2 0 9226 1 7986 314 419 mx2_x2
xsubckt_7482_mx2_x2 0 9228 1 7986 318 423 mx2_x2
xsubckt_7286_oa22_x2 0 9299 1 8133 8109 8107 oa22_x2
xsubckt_7232_a3_x2 1 8147 0 8151 7132 7194 a3_x2
xsubckt_6602_mx2_x2 0 2044 1 712 2045 2046 mx2_x2
xsubckt_6600_mx2_x2 0 2046 1 710 1403 1243 mx2_x2
xsubckt_6211_mx2_x2 0 2427 1 710 2428 2429 mx2_x2
xsubckt_5561_a4_x2 0 2999 1 3007 1846 1844 1845 a4_x2
xsubckt_5087_nand3_x0 1 0 3413 40 113 7780 nand3_x0
xsubckt_3294_nxr2_x1 4677 1 0 221 693 nxr2_x1
xsubckt_2815_nor2_x0 1 0 5147 5148 7180 nor2_x0
xsubckt_1055_a3_x2 1 6767 0 6768 6769 6878 a3_x2
xsubckt_881_nand2_x0 1 0 6933 1840 589 nand2_x0
xsubckt_372_inv_x0 1 0 1431 7419 inv_x0
xsubckt_374_inv_x0 1 0 1271 7417 inv_x0
xsubckt_376_inv_x0 1 0 1207 7415 inv_x0
xsubckt_9713_sff1_x4 1 1872 0 8763 774 sff1_x4
xsubckt_8891_sff1_x4 1 1872 0 9502 1808 sff1_x4
xsubckt_8813_sff1_x4 1 1872 0 9580 1754 sff1_x4
xsubckt_8456_sff1_x4 1 1872 0 9937 730 sff1_x4
xsubckt_8014_a2_x2 0 7810 1 3793 3796 a2_x2
xsubckt_7488_mx2_x2 0 9222 1 7985 415 310 mx2_x2
xsubckt_7272_a3_x2 1 8116 0 8117 7132 7194 a3_x2
xsubckt_6951_mx2_x2 0 8347 1 712 1203 1171 mx2_x2
xsubckt_6691_mx3_x2 1 0 1957 712 710 1958 857 1369 mx3_x2
xsubckt_6386_oa22_x2 0 2256 1 40 1741 192 oa22_x2
xsubckt_6213_mx2_x2 0 2425 1 712 1220 1188 mx2_x2
xsubckt_5414_a3_x2 1 3110 0 3111 3113 3115 a3_x2
xsubckt_4811_nand2_x0 1 0 3627 1777 1776 nand2_x0
xsubckt_4700_a3_x2 1 3715 0 1773 1745 1744 a3_x2
xsubckt_4291_a3_x2 1 3790 0 7209 520 7211 a3_x2
xsubckt_3903_ao22_x2 0 4078 1 7218 4095 4079 ao22_x2
xsubckt_3676_nand2_x0 1 0 4301 4302 704 nand2_x0
xsubckt_3651_nxr2_x1 4326 1 0 4327 4333 nxr2_x1
xsubckt_2994_mx2_x2 0 4971 1 707 901 869 mx2_x2
xsubckt_2992_mx2_x2 0 4973 1 707 1733 1381 mx2_x2
xsubckt_1095_a3_x2 1 6729 0 6730 6748 6753 a3_x2
xsubckt_877_nand3_x0 1 0 6937 6938 6940 6941 nand3_x0
xsubckt_791_nand2_x0 1 0 7019 588 1806 nand2_x0
xsubckt_378_inv_x0 1 0 1079 7413 inv_x0
xsubckt_1824_nand2_x0 1 0 1905 6027 6031 nand2_x0
xsubckt_2258_mx2_x2 0 5694 1 710 1425 1265 mx2_x2
xsubckt_9787_sff1_x4 1 1872 0 8689 1691 sff1_x4
xsubckt_9709_sff1_x4 1 1872 0 8767 748 sff1_x4
xsubckt_9264_sff1_x4 1 1872 0 9197 304 sff1_x4
xsubckt_8887_sff1_x4 1 1872 0 9506 1826 sff1_x4
xsubckt_8364_sff1_x4 1 1872 0 10021 1575 sff1_x4
xsubckt_7340_a2_x2 0 8067 1 537 40 a2_x2
xsubckt_6942_ao22_x2 0 8355 1 534 532 682 ao22_x2
xsubckt_5815_mx3_x2 1 0 2811 712 710 2812 7616 7618 mx3_x2
xsubckt_5542_a2_x2 0 9484 1 3013 3014 a2_x2
xsubckt_5494_a3_x2 1 9497 0 3048 3049 40 a3_x2
xsubckt_5299_a3_x2 1 3218 0 40 125 7780 a3_x2
xsubckt_5160_nand3_x0 1 0 3346 40 137 7780 nand3_x0
xsubckt_5033_mx3_x2 1 0 3460 5754 518 7778 7302 7303 mx3_x2
xsubckt_4171_o4_x2 0 3833 1 3842 7736 7737 7738 o4_x2
xsubckt_3454_ao22_x2 0 4520 1 4567 4565 4566 ao22_x2
xsubckt_1163_a2_x2 0 6664 1 220 1739 a2_x2
xsubckt_1297_ao22_x2 0 6537 1 6538 6542 7038 ao22_x2
xsubckt_1612_a2_x2 0 6229 1 6230 6316 a2_x2
xsubckt_1734_nand2_x0 1 0 6107 6112 6138 nand2_x0
xsubckt_9695_sff1_x4 1 1872 0 8781 791 sff1_x4
xsubckt_9621_sff1_x4 1 1872 0 8852 863 sff1_x4
xsubckt_8809_sff1_x4 1 1872 0 9584 1758 sff1_x4
xsubckt_8721_sff1_x4 1 1872 0 9672 1104 sff1_x4
xsubckt_7634_a2_x2 0 9173 1 7887 7891 a2_x2
xsubckt_7365_nand2_x0 1 0 8049 8138 578 nand2_x0
xsubckt_6305_nand2_x0 1 0 2335 2336 7631 nand2_x0
xsubckt_6294_oa22_x2 0 2346 1 40 1741 194 oa22_x2
xsubckt_5836_a2_x2 0 2790 1 2792 7613 a2_x2
xsubckt_5777_nand3_x0 1 0 2846 5606 644 7690 nand3_x0
xsubckt_5768_a3_x2 1 9416 0 2855 7195 40 a3_x2
xsubckt_5607_ao22_x2 0 2965 1 2970 1831 40 ao22_x2
xsubckt_5423_nand2_x0 1 0 3102 3457 7672 nand2_x0
xsubckt_5394_oa22_x2 0 3129 1 3131 3132 7690 oa22_x2
xsubckt_5355_nxr2_x1 3165 1 0 3472 665 nxr2_x1
xsubckt_5327_nor2_x0 1 0 3191 3192 3206 nor2_x0
xsubckt_5037_mx3_x2 1 0 3457 5754 518 7779 7300 7301 mx3_x2
xsubckt_4943_oa22_x2 0 9568 1 7168 3528 3530 oa22_x2
xsubckt_4785_ao22_x2 0 3647 1 1782 3649 40 ao22_x2
xsubckt_4673_a2_x2 0 9629 1 3737 3738 a2_x2
xsubckt_3549_a2_x2 0 4426 1 4427 4428 a2_x2
xsubckt_1078_mx3_x2 1 0 6745 307 229 308 7287 7644 mx3_x2
xsubckt_1457_a2_x2 0 6384 1 6385 6390 a2_x2
xsubckt_1644_nand2_x0 1 0 6197 6198 6331 nand2_x0
xsubckt_1878_a3_x2 1 5978 0 5987 6206 6224 a3_x2
xsubckt_2206_o3_x2 0 5745 1 648 647 646 o3_x2
xsubckt_2353_o4_x2 0 5601 1 1739 1741 1738 1737 o4_x2
xsubckt_9617_sff1_x4 1 1872 0 8856 867 sff1_x4
xsubckt_9172_sff1_x4 1 1872 0 9286 583 sff1_x4
xsubckt_8795_sff1_x4 1 1872 0 9598 1774 sff1_x4
xsubckt_6938_ao22_x2 0 8359 1 8360 8362 708 ao22_x2
xsubckt_6658_nor2_x0 1 0 1989 1990 7134 nor2_x0
xsubckt_5263_nxr2_x1 3251 1 0 3258 3489 nxr2_x1
xsubckt_5158_ao22_x2 0 3347 1 7101 3352 3348 ao22_x2
xsubckt_3784_a2_x2 0 4195 1 4196 7217 a2_x2
xsubckt_2647_o4_x2 0 5311 1 5312 5356 5594 5609 o4_x2
xsubckt_1131_o2_x2 0 6694 1 6695 6696 o2_x2
xsubckt_770_nand3_x0 1 0 7039 7040 7046 7049 nand3_x0
xsubckt_1544_xr2_x1 6297 0 1 417 201 xr2_x1
xsubckt_1886_oa22_x2 0 1929 1 6111 5975 5971 oa22_x2
xsubckt_9168_sff1_x4 1 1872 0 9290 571 sff1_x4
xsubckt_9080_sff1_x4 1 1872 0 9346 1296 sff1_x4
xsubckt_8717_sff1_x4 1 1872 0 9676 1109 sff1_x4
xsubckt_7095_nand2_x0 1 0 8206 1231 710 nand2_x0
xsubckt_6846_ao22_x2 0 8449 1 534 532 684 ao22_x2
xsubckt_5329_nand3_x0 1 0 3190 40 123 7780 nand3_x0
xsubckt_4939_oa22_x2 0 9569 1 7168 3531 3533 oa22_x2
xsubckt_4462_mx3_x2 1 0 9802 3777 3896 1011 3805 3807 mx3_x2
xsubckt_4460_mx3_x2 1 0 9804 3777 3896 1013 3811 3813 mx3_x2
xsubckt_3684_o3_x2 0 4293 1 4294 4296 7218 o3_x2
xsubckt_3243_o2_x2 0 4727 1 222 694 o2_x2
xsubckt_3071_oa22_x2 0 4895 1 4896 4905 704 oa22_x2
xsubckt_951_oa22_x2 0 6866 1 1737 6875 6867 oa22_x2
xsubckt_680_nand3_x0 1 0 7117 7185 7189 7192 nand3_x0
xsubckt_1548_xr2_x1 6293 0 1 418 202 xr2_x1
xsubckt_1720_oa22_x2 0 6121 1 6145 6197 604 oa22_x2
xsubckt_2256_nand2_x0 1 0 298 5696 5700 nand2_x0
xsubckt_9525_sff1_x4 1 1872 0 8941 951 sff1_x4
xsubckt_9002_sff1_x4 1 1872 0 9423 498 sff1_x4
xsubckt_8034_mx3_x2 1 0 8819 7810 3896 830 3835 3837 mx3_x2
xsubckt_8032_mx3_x2 1 0 8821 7810 3896 832 3841 3843 mx3_x2
xsubckt_8030_mx3_x2 1 0 8823 7810 3896 834 3847 3849 mx3_x2
xsubckt_6462_nand3_x0 1 0 2181 2186 2188 709 nand3_x0
xsubckt_5946_ao22_x2 0 2686 1 7628 2691 708 ao22_x2
xsubckt_5224_oa22_x2 0 3287 1 3293 3294 3295 oa22_x2
xsubckt_4464_mx3_x2 1 0 9800 3777 3896 1008 3799 3801 mx3_x2
xsubckt_4335_mx2_x2 0 9920 1 3785 3874 1516 mx2_x2
xsubckt_4333_mx2_x2 0 9922 1 3785 3882 1518 mx2_x2
xsubckt_4331_mx2_x2 0 9924 1 3785 3890 1532 mx2_x2
xsubckt_3958_nor2_x0 1 0 4024 4025 7216 nor2_x0
xsubckt_9599_sff1_x4 1 1872 0 8874 916 sff1_x4
xsubckt_9076_sff1_x4 1 1872 0 9350 1301 sff1_x4
xsubckt_8625_sff1_x4 1 1872 0 9768 1456 sff1_x4
xsubckt_8038_mx3_x2 1 0 8815 7810 3896 825 3823 3825 mx3_x2
xsubckt_8036_mx3_x2 1 0 8817 7810 3896 827 3829 3831 mx3_x2
xsubckt_7654_ao22_x2 0 7870 1 7953 8018 353 ao22_x2
xsubckt_6990_oa22_x2 0 8309 1 40 1741 179 oa22_x2
xsubckt_6578_o2_x2 0 2068 1 2069 711 o2_x2
xsubckt_5580_nand3_x0 1 0 2985 2991 1839 1840 nand3_x0
xsubckt_5500_nor2_x0 1 0 3043 3047 1863 nor2_x0
xsubckt_5497_ao22_x2 0 3045 1 3050 1864 40 ao22_x2
xsubckt_5143_nor2_x0 1 0 3361 3362 3363 nor2_x0
xsubckt_3792_o2_x2 0 4187 1 4188 4190 o2_x2
xsubckt_3411_mx2_x2 0 4562 1 705 1117 957 mx2_x2
xsubckt_3151_mx3_x2 1 0 4817 707 705 4818 1602 738 mx3_x2
xsubckt_1016_nand2_x0 1 0 6804 587 1769 nand2_x0
xsubckt_9433_sff1_x4 1 1872 0 9033 1360 sff1_x4
xsubckt_8699_sff1_x4 1 1872 0 9694 1098 sff1_x4
xsubckt_7562_ao22_x2 0 9188 1 7956 7944 7946 ao22_x2
xsubckt_7114_mx3_x2 1 0 8187 711 7620 8188 8200 8212 mx3_x2
xsubckt_7112_mx3_x2 1 0 8189 708 7631 8190 8192 8193 mx3_x2
xsubckt_6912_oa22_x2 0 8385 1 7631 8390 711 oa22_x2
xsubckt_5843_nand2_x0 1 0 2783 7134 446 nand2_x0
xsubckt_4299_mx2_x2 0 9953 1 3788 3878 717 mx2_x2
xsubckt_4297_mx2_x2 0 9955 1 3788 3886 721 mx2_x2
xsubckt_4295_mx2_x2 0 9957 1 3788 3892 743 mx2_x2
xsubckt_3738_nand2_x0 1 0 4240 7217 1399 nand2_x0
xsubckt_3417_mx2_x2 0 4556 1 705 1437 1277 mx2_x2
xsubckt_3413_mx2_x2 0 4560 1 707 4561 4562 mx2_x2
xsubckt_3157_mx3_x2 1 0 4811 707 705 4812 866 1378 mx3_x2
xsubckt_2723_ao22_x2 0 5237 1 5238 5243 703 ao22_x2
xsubckt_2471_nxr2_x1 5484 1 0 5486 5539 nxr2_x1
xsubckt_763_nand2_x0 1 0 7045 308 7685 nand2_x0
xsubckt_673_nand2_x0 1 0 7122 1743 40 nand2_x0
xsubckt_2366_ao22_x2 0 5588 1 5591 652 7674 ao22_x2
xsubckt_9429_sff1_x4 1 1872 0 9037 1365 sff1_x4
xsubckt_8533_sff1_x4 1 1872 0 9860 1500 sff1_x4
xsubckt_8258_mx2_x2 0 9269 1 5752 9071 664 mx2_x2
xsubckt_7856_mx3_x2 1 0 8987 7820 3897 1190 3859 3860 mx3_x2
xsubckt_7854_mx3_x2 1 0 8989 7820 3897 1162 3867 3868 mx3_x2
xsubckt_6635_nand2_x0 1 0 2012 2013 711 nand2_x0
xsubckt_6545_nand2_x0 1 0 2100 2101 712 nand2_x0
xsubckt_6192_nand3_x0 1 0 2445 2446 2453 7613 nand3_x0
xsubckt_5396_nand4_x0 1 0 3127 3177 3462 3465 3468 nand4_x0
xsubckt_3558_nand2_x0 1 0 4417 4418 7219 nand2_x0
xsubckt_3419_mx2_x2 0 4554 1 705 1021 829 mx2_x2
xsubckt_832_a2_x2 0 6980 1 679 54 a2_x2
xsubckt_812_a2_x2 0 6999 1 7001 7014 a2_x2
xsubckt_617_a2_x2 0 7174 1 1738 481 a2_x2
xsubckt_220_inv_x0 1 0 1453 7571 inv_x0
xsubckt_1353_nand3_x0 1 0 6484 6485 6486 6487 nand3_x0
xsubckt_1706_nand2_x0 1 0 6135 423 207 nand2_x0
xsubckt_1884_nand2_x0 1 0 5972 6112 6327 nand2_x0
xsubckt_2200_ao22_x2 0 5750 1 6142 6119 5751 ao22_x2
xsubckt_9864_sff1_x4 1 1872 0 8612 1639 sff1_x4
xsubckt_9341_sff1_x4 1 1872 0 9120 1035 sff1_x4
xsubckt_8964_sff1_x4 1 1872 0 162 99 sff1_x4
xsubckt_8529_sff1_x4 1 1872 0 9864 976 sff1_x4
xsubckt_8441_sff1_x4 1 1872 0 9952 716 sff1_x4
xsubckt_7858_mx3_x2 1 0 8985 7820 3896 1188 3853 3855 mx3_x2
xsubckt_7558_ao22_x2 0 9189 1 7956 7947 7949 ao22_x2
xsubckt_6455_nand2_x0 1 0 2188 2189 7631 nand2_x0
xsubckt_3811_nand2_x0 1 0 4168 4169 4177 nand2_x0
xsubckt_3377_mx2_x2 0 4595 1 707 4596 4597 mx2_x2
xsubckt_3375_mx2_x2 0 4597 1 705 1406 1246 mx2_x2
xsubckt_2840_mx2_x2 0 5122 1 7217 7546 7550 mx2_x2
xsubckt_1173_nand3_x0 1 0 6655 6656 6657 1740 nand3_x0
xsubckt_872_a2_x2 0 6942 1 6943 1740 a2_x2
xsubckt_697_a2_x2 0 7104 1 7109 1739 a2_x2
xsubckt_222_inv_x0 1 0 1293 7569 inv_x0
xsubckt_224_inv_x0 1 0 1003 7567 inv_x0
xsubckt_226_inv_x0 1 0 811 7565 inv_x0
xsubckt_2239_mx3_x2 1 0 5712 7620 712 5713 5715 5716 mx3_x2
xsubckt_2274_ao22_x2 0 5678 1 5679 5681 709 ao22_x2
xsubckt_2439_nor2_x0 1 0 5516 5517 704 nor2_x0
xsubckt_9772_sff1_x4 1 1872 0 8704 1677 sff1_x4
xsubckt_9337_sff1_x4 1 1872 0 9124 1041 sff1_x4
xsubckt_7336_a4_x2 0 8070 1 373 7659 371 538 a4_x2
xsubckt_6932_mx3_x2 1 0 8365 712 710 8366 7391 7393 mx3_x2
xsubckt_6412_mx2_x2 0 2230 1 710 1472 1312 mx2_x2
xsubckt_6365_nand2_x0 1 0 2276 2277 2280 nand2_x0
xsubckt_6150_mx3_x2 1 0 2486 7613 7620 2487 2494 2497 mx3_x2
xsubckt_5569_nand3_x0 1 0 2993 2999 1842 1843 nand3_x0
xsubckt_5559_oa22_x2 0 3000 1 3007 1846 1845 oa22_x2
xsubckt_5471_oa22_x2 0 3064 1 1810 3071 1809 oa22_x2
xsubckt_5404_nor2_x0 1 0 3120 3127 3460 nor2_x0
xsubckt_4804_a4_x2 0 3633 1 1785 1783 1782 1779 a4_x2
xsubckt_3962_ao22_x2 0 4020 1 7254 7155 7152 ao22_x2
xsubckt_3378_nand2_x0 1 0 4594 705 7490 nand2_x0
xsubckt_3288_nand2_x0 1 0 4682 4683 4690 nand2_x0
xsubckt_3240_oa22_x2 0 4730 1 5595 5608 222 oa22_x2
xsubckt_3192_xr2_x1 4777 0 1 223 695 xr2_x1
xsubckt_2496_nand2_x0 1 0 5460 5461 5468 nand2_x0
xsubckt_575_inv_x0 1 0 704 7216 inv_x0
xsubckt_573_inv_x0 1 0 706 7218 inv_x0
xsubckt_571_inv_x0 1 0 527 7220 inv_x0
xsubckt_184_inv_x0 1 0 903 7607 inv_x0
xsubckt_182_inv_x0 1 0 1031 7609 inv_x0
xsubckt_180_inv_x0 1 0 1735 7611 inv_x0
xsubckt_228_inv_x0 1 0 1675 7563 inv_x0
xsubckt_1526_nand2_x0 1 0 6315 7240 228 nand2_x0
xsubckt_2318_nand2_x0 1 0 5635 5636 5641 nand2_x0
xsubckt_8872_sff1_x4 1 1872 0 9521 125 sff1_x4
xsubckt_8437_sff1_x4 1 1872 0 9956 732 sff1_x4
xsubckt_7320_nand2_x0 1 0 8083 8095 8120 nand2_x0
xsubckt_7249_a3_x2 1 8133 0 373 7659 7661 a3_x2
xsubckt_7229_a3_x2 1 8149 0 9090 9091 8153 a3_x2
xsubckt_7101_oa22_x2 0 8200 1 8201 8204 8207 oa22_x2
xsubckt_6414_mx2_x2 0 2228 1 712 2229 2230 mx2_x2
xsubckt_6367_oa22_x2 0 2274 1 2275 2288 7628 oa22_x2
xsubckt_5478_nor2_x0 1 0 3059 3063 1869 nor2_x0
xsubckt_5428_nxr2_x1 3097 1 0 3120 3456 nxr2_x1
xsubckt_4669_a4_x2 0 3739 1 3740 3749 3754 3763 a4_x2
xsubckt_3184_nand4_x0 1 0 4784 5604 532 7689 71 nand4_x0
xsubckt_1001_a2_x2 0 6819 1 699 74 a2_x2
xsubckt_800_o2_x2 0 7010 1 7011 7016 o2_x2
xsubckt_772_o3_x2 0 7037 1 1739 1737 1740 o3_x2
xsubckt_759_oa22_x2 0 7049 1 7050 7053 7297 oa22_x2
xsubckt_579_inv_x0 1 0 523 7212 inv_x0
xsubckt_577_inv_x0 1 0 535 7214 inv_x0
xsubckt_188_inv_x0 1 0 743 7603 inv_x0
xsubckt_186_inv_x0 1 0 839 7605 inv_x0
xsubckt_2340_oa22_x2 0 5613 1 5614 5622 708 oa22_x2
xsubckt_9768_sff1_x4 1 1872 0 8708 1703 sff1_x4
xsubckt_9680_sff1_x4 1 1872 0 8796 777 sff1_x4
xsubckt_9245_sff1_x4 1 1872 0 9216 334 sff1_x4
xsubckt_6763_mx2_x2 0 8531 1 710 1495 1335 mx2_x2
xsubckt_6761_mx2_x2 0 8533 1 711 8534 8537 mx2_x2
xsubckt_6418_mx2_x2 0 2224 1 710 1440 1280 mx2_x2
xsubckt_6374_mx2_x2 0 2267 1 710 1185 1057 mx2_x2
xsubckt_6372_mx2_x2 0 2269 1 710 1377 865 mx2_x2
xsubckt_6370_mx2_x2 0 2271 1 712 2272 2273 mx2_x2
xsubckt_6095_nand2_x0 1 0 2540 2541 712 nand2_x0
xsubckt_6029_mx2_x2 0 2605 1 712 1066 1034 mx2_x2
xsubckt_6027_mx2_x2 0 2607 1 712 1130 1098 mx2_x2
xsubckt_5626_a3_x2 1 9461 0 2952 2953 40 a3_x2
xsubckt_5265_a2_x2 0 3249 1 3489 666 a2_x2
xsubckt_5225_a2_x2 0 3286 1 3498 652 a2_x2
xsubckt_4932_a3_x2 1 3536 0 40 51 7780 a3_x2
xsubckt_3590_nor2_x0 1 0 4386 4387 7219 nor2_x0
xsubckt_1081_a2_x2 0 6742 1 7143 1865 a2_x2
xsubckt_1256_nand2_x0 1 0 6576 588 1791 nand2_x0
xsubckt_2029_a2_x2 0 5840 1 6387 6394 a2_x2
xsubckt_2138_nand2_x0 1 0 5758 7044 180 nand2_x0
xsubckt_2391_a3_x2 1 5563 0 5564 5570 706 a3_x2
xsubckt_9602_sff1_x4 1 1872 0 8871 912 sff1_x4
xsubckt_8868_sff1_x4 1 1872 0 9525 130 sff1_x4
xsubckt_8780_sff1_x4 1 1872 0 9613 1790 sff1_x4
xsubckt_8345_sff1_x4 1 1872 0 10040 1602 sff1_x4
xsubckt_7532_oa22_x2 0 7967 1 7970 7093 7213 oa22_x2
xsubckt_7397_a2_x2 0 8023 1 7664 363 a2_x2
xsubckt_6488_a2_x2 0 2156 1 2159 7613 a2_x2
xsubckt_6376_mx2_x2 0 2265 1 710 769 1633 mx2_x2
xsubckt_6275_oa22_x2 0 2364 1 2365 2380 7620 oa22_x2
xsubckt_5734_a2_x2 0 2858 1 7697 40 a2_x2
xsubckt_4992_a3_x2 1 3491 0 40 66 7780 a3_x2
xsubckt_4972_a3_x2 1 3506 0 40 71 7780 a3_x2
xsubckt_4952_a3_x2 1 3521 0 40 46 7780 a3_x2
xsubckt_4777_a3_x2 1 3653 0 3657 1786 1785 a3_x2
xsubckt_4063_nand2_x0 1 0 3921 3922 707 nand2_x0
xsubckt_3978_nand2_x0 1 0 4005 208 680 nand2_x0
xsubckt_3700_nand3_x0 1 0 4277 4278 4482 7104 nand3_x0
xsubckt_3667_oa22_x2 0 4310 1 4311 705 707 oa22_x2
xsubckt_3642_a2_x2 0 10063 1 4335 4401 a2_x2
xsubckt_3467_a2_x2 0 4507 1 4513 703 a2_x2
xsubckt_2778_nor2_x0 1 0 5183 5184 7218 nor2_x0
xsubckt_1166_nand2_x0 1 0 161 6662 6673 nand2_x0
xsubckt_1278_ao22_x2 0 6555 1 6556 6560 7038 ao22_x2
xsubckt_1355_a2_x2 0 6482 1 209 1739 a2_x2
xsubckt_1383_nxr2_x1 6456 1 0 6458 6459 nxr2_x1
xsubckt_1959_oa22_x2 0 5904 1 5905 5908 6371 oa22_x2
xsubckt_2089_a2_x2 0 5788 1 5789 5790 a2_x2
xsubckt_2255_nor2_x0 1 0 5696 5697 7103 nor2_x0
xsubckt_9676_sff1_x4 1 1872 0 8800 781 sff1_x4
xsubckt_9153_sff1_x4 1 1872 0 9305 603 sff1_x4
xsubckt_8702_sff1_x4 1 1872 0 9691 1125 sff1_x4
xsubckt_6919_ao22_x2 0 8378 1 8382 8381 8379 ao22_x2
xsubckt_5898_oa22_x2 0 2732 1 7573 7081 7134 oa22_x2
xsubckt_5574_ao22_x2 0 2989 1 2994 1841 40 ao22_x2
xsubckt_5145_o3_x2 0 3359 1 3360 3361 7690 o3_x2
xsubckt_5139_ao22_x2 0 3365 1 600 3366 644 ao22_x2
xsubckt_4817_nor3_x0 1 0 3622 3627 3631 7712 nor3_x0
xsubckt_4314_mx3_x2 1 0 9938 3789 3896 731 3829 3831 mx3_x2
xsubckt_4312_mx3_x2 1 0 9940 3789 3896 734 3835 3837 mx3_x2
xsubckt_4310_mx3_x2 1 0 9942 3789 3896 736 3841 3843 mx3_x2
xsubckt_3936_a2_x2 0 4046 1 4047 704 a2_x2
xsubckt_3501_oa22_x2 0 4474 1 5595 5608 216 oa22_x2
xsubckt_2828_nand2_x0 1 0 5134 5135 7215 nand2_x0
xsubckt_2767_oa22_x2 0 5194 1 707 5195 704 oa22_x2
xsubckt_2598_a2_x2 0 5360 1 204 676 a2_x2
xsubckt_2475_nand3_x0 1 0 5480 5481 5482 7104 nand3_x0
xsubckt_1689_a2_x2 0 6152 1 6153 6154 a2_x2
xsubckt_2121_nand2_x0 1 0 439 5763 5766 nand2_x0
xsubckt_9510_sff1_x4 1 1872 0 8956 937 sff1_x4
xsubckt_8776_sff1_x4 1 1872 0 9617 1794 sff1_x4
xsubckt_7440_oa22_x2 0 9243 1 8147 8012 8011 oa22_x2
xsubckt_7091_o2_x2 0 8210 1 8211 7631 o2_x2
xsubckt_6607_nand2_x0 1 0 2039 2040 7620 nand2_x0
xsubckt_6382_ao22_x2 0 2259 1 534 532 695 ao22_x2
xsubckt_5732_oa22_x2 0 2860 1 7790 7161 7158 oa22_x2
xsubckt_5725_nand2_x0 1 0 2866 2867 2869 nand2_x0
xsubckt_4921_mx2_x2 0 3544 1 5753 3893 139 mx2_x2
xsubckt_4318_mx3_x2 1 0 9934 3789 3896 727 3817 3819 mx3_x2
xsubckt_4316_mx3_x2 1 0 9936 3789 3896 729 3823 3825 mx3_x2
xsubckt_4270_mx3_x2 1 0 9979 3792 3897 901 3856 3857 mx3_x2
xsubckt_3575_oa22_x2 0 4401 1 5595 5608 215 oa22_x2
xsubckt_3508_nor2_x0 1 0 4467 4468 7180 nor2_x0
xsubckt_3339_ao22_x2 0 4633 1 5594 5609 7268 ao22_x2
xsubckt_1303_o2_x2 0 6532 1 683 58 o2_x2
xsubckt_9584_sff1_x4 1 1872 0 8889 932 sff1_x4
xsubckt_9506_sff1_x4 1 1872 0 8960 941 sff1_x4
xsubckt_9149_sff1_x4 1 1872 0 9309 607 sff1_x4
xsubckt_9061_sff1_x4 1 1872 0 9365 1317 sff1_x4
xsubckt_8684_sff1_x4 1 1872 0 9709 1430 sff1_x4
xsubckt_8610_sff1_x4 1 1872 0 9783 1473 sff1_x4
xsubckt_8233_mx3_x2 1 0 8600 7798 3896 1635 3850 3852 mx3_x2
xsubckt_8231_mx3_x2 1 0 8602 7798 3897 1637 3856 3857 mx3_x2
xsubckt_7079_oa22_x2 0 8222 1 7625 1679 8223 oa22_x2
xsubckt_6517_nand2_x0 1 0 2127 2128 2130 nand2_x0
xsubckt_5283_oa22_x2 0 3232 1 7102 3237 3233 oa22_x2
xsubckt_4536_mx2_x2 0 9734 1 3770 3894 1448 mx2_x2
xsubckt_4276_mx3_x2 1 0 9973 3792 3896 895 3838 3840 mx3_x2
xsubckt_4274_mx3_x2 1 0 9975 3792 3896 897 3844 3846 mx3_x2
xsubckt_4272_mx3_x2 1 0 9977 3792 3896 899 3850 3852 mx3_x2
xsubckt_3939_nor2_x0 1 0 4043 4044 7219 nor2_x0
xsubckt_3709_o2_x2 0 4269 1 213 685 o2_x2
xsubckt_2901_nand2_x0 1 0 5062 5063 7215 nand2_x0
xsubckt_2526_o2_x2 0 5430 1 5431 707 o2_x2
xsubckt_1168_o2_x2 0 6660 1 691 66 o2_x2
xsubckt_1617_o2_x2 0 6224 1 195 225 o2_x2
xsubckt_1766_nand2_x0 1 0 6079 6116 6263 nand2_x0
xsubckt_1900_ao22_x2 0 5958 1 5962 5961 5959 ao22_x2
xsubckt_9057_sff1_x4 1 1872 0 9369 1291 sff1_x4
xsubckt_8606_sff1_x4 1 1872 0 9787 1477 sff1_x4
xsubckt_8239_mx3_x2 1 0 8594 7798 3896 1629 3832 3834 mx3_x2
xsubckt_8237_mx3_x2 1 0 8596 7798 3896 1631 3838 3840 mx3_x2
xsubckt_8235_mx3_x2 1 0 8598 7798 3896 1633 3844 3846 mx3_x2
xsubckt_7650_nand2_x0 1 0 7873 348 536 nand2_x0
xsubckt_6290_ao22_x2 0 2349 1 534 532 697 ao22_x2
xsubckt_5455_nand2_x0 1 0 3076 3079 1837 nand2_x0
xsubckt_5279_oa22_x2 0 3236 1 7680 3487 7167 oa22_x2
xsubckt_5152_nxr2_x1 3353 1 0 3517 7656 nxr2_x1
xsubckt_4740_oa22_x2 0 3682 1 3685 1794 1793 oa22_x2
xsubckt_4538_mx2_x2 0 9732 1 3770 3890 1436 mx2_x2
xsubckt_4278_mx3_x2 1 0 9971 3792 3896 893 3832 3834 mx3_x2
xsubckt_3007_mx3_x2 1 0 4958 707 705 4959 1253 1413 mx3_x2
xsubckt_2811_nand2_x0 1 0 5151 200 672 nand2_x0
xsubckt_982_nand3_x0 1 0 6837 6839 6840 6859 nand3_x0
xsubckt_602_a3_x2 1 7189 0 1737 40 7784 a3_x2
xsubckt_1676_nand2_x0 1 0 6165 7231 212 nand2_x0
xsubckt_9492_sff1_x4 1 1872 0 8974 1176 sff1_x4
xsubckt_9414_sff1_x4 1 1872 0 9052 1381 sff1_x4
xsubckt_8592_sff1_x4 1 1872 0 9801 1010 sff1_x4
xsubckt_8195_mx3_x2 1 0 8636 7800 3897 1225 3863 3864 mx3_x2
xsubckt_8193_mx3_x2 1 0 8638 7800 3897 1227 3871 3872 mx3_x2
xsubckt_5636_oa22_x2 0 2944 1 1823 2951 1822 oa22_x2
xsubckt_4659_nand3_x0 1 0 3747 3749 3754 3763 nand3_x0
xsubckt_3682_ao22_x2 0 4295 1 920 705 707 ao22_x2
xsubckt_3614_mx2_x2 0 4362 1 7217 7436 7438 mx2_x2
xsubckt_3612_mx2_x2 0 4364 1 705 1657 1529 mx2_x2
xsubckt_3604_ao22_x2 0 4372 1 4373 4375 706 ao22_x2
xsubckt_3405_oa22_x2 0 4568 1 5595 5608 219 oa22_x2
xsubckt_3223_mx2_x2 0 4746 1 705 1697 1569 mx2_x2
xsubckt_1209_nxr2_x1 6621 1 0 688 63 nxr2_x1
xsubckt_1496_nand2_x0 1 0 6345 189 219 nand2_x0
xsubckt_2010_nand3_x0 1 0 5857 5858 5859 6111 nand3_x0
xsubckt_2060_oa22_x2 0 1912 1 6111 5816 5812 oa22_x2
xsubckt_2362_nor4_x0 1 0 5592 653 651 650 666 nor4_x0
xsubckt_9488_sff1_x4 1 1872 0 8978 1181 sff1_x4
xsubckt_8514_sff1_x4 1 1872 0 9879 993 sff1_x4
xsubckt_8199_mx3_x2 1 0 8632 7800 3896 1251 3850 3852 mx3_x2
xsubckt_8197_mx3_x2 1 0 8634 7800 3897 1253 3856 3857 mx3_x2
xsubckt_7920_mx2_x2 0 8927 1 7815 3874 1196 mx2_x2
xsubckt_6067_nand2_x0 1 0 2567 2568 2570 nand2_x0
xsubckt_5555_nor2_x0 1 0 3003 3007 1846 nor2_x0
xsubckt_5386_ao22_x2 0 3136 1 600 3137 644 ao22_x2
xsubckt_4908_nand4_x0 1 0 3553 3562 1753 1752 1750 nand4_x0
xsubckt_4160_nxr2_x1 3841 1 0 3845 69 nxr2_x1
xsubckt_3618_mx2_x2 0 4358 1 705 1209 1081 mx2_x2
xsubckt_3333_nand2_x0 1 0 4638 7153 7271 nand2_x0
xsubckt_3227_mx2_x2 0 4742 1 706 4743 4745 mx2_x2
xsubckt_3225_mx2_x2 0 4744 1 705 769 1633 mx2_x2
xsubckt_2940_oa22_x2 0 5024 1 5025 5033 704 oa22_x2
xsubckt_2821_mx3_x2 1 0 5141 704 7219 5142 5145 5146 mx3_x2
xsubckt_2541_nand2_x0 1 0 5415 7152 7292 nand2_x0
xsubckt_1167_nor2_x0 1 0 6661 691 66 nor2_x0
xsubckt_421_inv_x0 1 0 783 7370 inv_x0
xsubckt_9845_sff1_x4 1 1872 0 8631 1250 sff1_x4
xsubckt_9322_sff1_x4 1 1872 0 9139 1339 sff1_x4
xsubckt_8588_sff1_x4 1 1872 0 9805 1014 sff1_x4
xsubckt_7620_nor2_x0 1 0 7898 7899 7900 nor2_x0
xsubckt_7144_mx2_x2 0 9372 1 8166 3882 1294 mx2_x2
xsubckt_7142_mx2_x2 0 9374 1 8166 3890 1308 mx2_x2
xsubckt_7140_mx2_x2 0 9376 1 8166 3894 1320 mx2_x2
xsubckt_6230_nand2_x0 1 0 2408 2409 2414 nand2_x0
xsubckt_5220_ao22_x2 0 3290 1 3291 3292 3296 ao22_x2
xsubckt_5109_oa22_x2 0 3392 1 7102 3397 3393 oa22_x2
xsubckt_5056_nxr2_x1 3441 1 0 3541 647 nxr2_x1
xsubckt_2827_mx3_x2 1 0 5135 7216 707 5138 5136 5137 mx3_x2
xsubckt_423_inv_x0 1 0 719 7368 inv_x0
xsubckt_425_inv_x0 1 0 1647 7366 inv_x0
xsubckt_427_inv_x0 1 0 1583 7364 inv_x0
xsubckt_2434_mx3_x2 1 0 5521 707 705 5522 7604 7608 mx3_x2
xsubckt_9396_sff1_x4 1 1872 0 9065 353 sff1_x4
xsubckt_8945_sff1_x4 1 1872 0 9448 1811 sff1_x4
xsubckt_8422_sff1_x4 1 1872 0 9971 893 sff1_x4
xsubckt_7884_mx2_x2 0 8961 1 7817 3882 942 mx2_x2
xsubckt_7882_mx2_x2 0 8963 1 7817 3890 956 mx2_x2
xsubckt_7880_mx2_x2 0 8965 1 7817 3894 968 mx2_x2
xsubckt_7493_mx2_x2 0 9217 1 7985 440 335 mx2_x2
xsubckt_7491_mx2_x2 0 9219 1 7985 442 337 mx2_x2
xsubckt_7146_mx2_x2 0 9370 1 8166 3874 1292 mx2_x2
xsubckt_7119_nor4_x0 1 0 8183 6120 6141 6142 7789 nor4_x0
xsubckt_6875_oa22_x2 0 8421 1 7631 8426 711 oa22_x2
xsubckt_6639_ao22_x2 0 2008 1 2009 2010 708 ao22_x2
xsubckt_5901_oa22_x2 0 2730 1 40 1741 419 oa22_x2
xsubckt_5413_nxr2_x1 3111 1 0 3460 7672 nxr2_x1
xsubckt_5095_oa22_x2 0 3405 1 7680 3532 7167 oa22_x2
xsubckt_4702_a4_x2 0 3713 1 1807 1806 1795 1784 a4_x2
xsubckt_4156_nxr2_x1 3844 1 0 3848 7735 nxr2_x1
xsubckt_3153_nand2_x0 1 0 4815 4816 7215 nand2_x0
xsubckt_889_a2_x2 0 6926 1 674 49 a2_x2
xsubckt_637_nor3_x0 1 0 7157 594 600 607 nor3_x0
xsubckt_381_inv_x0 1 0 1238 7410 inv_x0
xsubckt_383_inv_x0 1 0 917 7408 inv_x0
xsubckt_429_inv_x0 1 0 1519 7362 inv_x0
xsubckt_1655_nand3_x0 1 0 6186 6342 7224 220 nand3_x0
xsubckt_2014_a3_x2 1 5853 0 5854 5855 5856 a3_x2
xsubckt_2261_mx2_x2 0 5691 1 710 1393 1233 mx2_x2
xsubckt_2361_nand2_x0 1 0 5593 5595 5608 nand2_x0
xsubckt_9753_sff1_x4 1 1872 0 8723 1726 sff1_x4
xsubckt_9318_sff1_x4 1 1872 0 9143 1344 sff1_x4
xsubckt_9230_sff1_x4 1 1872 0 9231 341 sff1_x4
xsubckt_8496_sff1_x4 1 1872 0 9897 1522 sff1_x4
xsubckt_8418_sff1_x4 1 1872 0 9975 897 sff1_x4
xsubckt_7886_mx2_x2 0 8959 1 7817 3874 940 mx2_x2
xsubckt_7499_mx2_x2 0 9211 1 7985 433 328 mx2_x2
xsubckt_7497_mx2_x2 0 9213 1 7985 436 331 mx2_x2
xsubckt_7495_mx2_x2 0 9215 1 7985 438 333 mx2_x2
xsubckt_7248_oa22_x2 0 9307 1 606 8138 8134 oa22_x2
xsubckt_5975_oa22_x2 0 2657 1 2658 2671 2728 oa22_x2
xsubckt_5651_ao22_x2 0 2933 1 2938 1818 40 ao22_x2
xsubckt_5524_a3_x2 1 3026 0 3031 1855 1856 a3_x2
xsubckt_3756_nand4_x0 1 0 4222 5604 532 7689 60 nand4_x0
xsubckt_3295_oa22_x2 0 4676 1 4728 4727 4726 oa22_x2
xsubckt_3237_a3_x2 1 4732 0 4733 5595 5608 a3_x2
xsubckt_3031_a2_x2 0 4935 1 705 7515 a2_x2
xsubckt_2658_mx2_x2 0 5301 1 707 5302 5303 mx2_x2
xsubckt_2656_mx2_x2 0 5303 1 705 1357 845 mx2_x2
xsubckt_385_inv_x0 1 0 789 7406 inv_x0
xsubckt_387_inv_x0 1 0 1397 7404 inv_x0
xsubckt_389_inv_x0 1 0 1237 7402 inv_x0
xsubckt_2003_nand2_x0 1 0 5864 6399 6404 nand2_x0
xsubckt_2265_mx2_x2 0 5687 1 711 1169 1105 mx2_x2
xsubckt_2267_mx2_x2 0 5685 1 711 1041 945 mx2_x2
xsubckt_2321_oa22_x2 0 5632 1 7579 7625 7631 oa22_x2
xsubckt_2409_oa22_x2 0 5545 1 7219 5546 7216 oa22_x2
xsubckt_9749_sff1_x4 1 1872 0 8727 1730 sff1_x4
xsubckt_8853_sff1_x4 1 1872 0 9540 117 sff1_x4
xsubckt_8330_sff1_x4 1 1872 0 10055 206 sff1_x4
xsubckt_8184_a2_x2 0 7800 1 3766 3787 a2_x2
xsubckt_7605_oa22_x2 0 7911 1 644 7679 692 oa22_x2
xsubckt_6920_nand2_x0 1 0 8377 8378 711 nand2_x0
xsubckt_6705_oa22_x2 0 1944 1 40 1741 185 oa22_x2
xsubckt_6573_mx2_x2 0 2073 1 712 1147 1115 mx2_x2
xsubckt_6306_a2_x2 0 2334 1 7499 710 a2_x2
xsubckt_5822_mx3_x2 1 0 2804 712 710 2805 7621 7623 mx3_x2
xsubckt_4810_a3_x2 1 9601 0 3628 3630 40 a3_x2
xsubckt_4801_nand4_x0 1 0 3635 3642 1780 1779 1778 nand4_x0
xsubckt_3933_nand2_x0 1 0 4049 4050 4051 nand2_x0
xsubckt_2543_a3_x2 1 5413 0 6912 7108 7152 a3_x2
xsubckt_2520_ao22_x2 0 5436 1 5437 5440 703 ao22_x2
xsubckt_1456_nxr2_x1 6385 1 0 182 211 nxr2_x1
xsubckt_1944_oa22_x2 0 5918 1 188 217 574 oa22_x2
xsubckt_2091_nand2_x0 1 0 415 5787 5790 nand2_x0
xsubckt_9661_sff1_x4 1 1872 0 8815 825 sff1_x4
xsubckt_9226_sff1_x4 1 1872 0 9235 535 sff1_x4
xsubckt_8849_sff1_x4 1 1872 0 9544 53 sff1_x4
xsubckt_8761_sff1_x4 1 1872 0 9632 1762 sff1_x4
xsubckt_8326_sff1_x4 1 1872 0 10059 211 sff1_x4
xsubckt_7591_oa22_x2 0 7922 1 644 7679 688 oa22_x2
xsubckt_6815_a2_x2 0 8480 1 8481 708 a2_x2
xsubckt_6740_nand2_x0 1 0 8553 8554 712 nand2_x0
xsubckt_6577_mx2_x2 0 2069 1 710 2070 2071 mx2_x2
xsubckt_6575_mx2_x2 0 2071 1 712 1083 1051 mx2_x2
xsubckt_6188_mx2_x2 0 2449 1 710 773 1637 mx2_x2
xsubckt_5672_a2_x2 0 9448 1 2919 40 a2_x2
xsubckt_5652_a2_x2 0 9454 1 2933 2934 a2_x2
xsubckt_5477_a2_x2 0 3060 1 3063 1869 a2_x2
xsubckt_5457_a2_x2 0 9507 1 3075 3076 a2_x2
xsubckt_4983_oa22_x2 0 9558 1 7168 3498 3500 oa22_x2
xsubckt_4723_a2_x2 0 9621 1 3697 3698 a2_x2
xsubckt_4695_a3_x2 1 3720 0 1746 1805 1804 a3_x2
xsubckt_4099_a2_x2 0 3889 1 65 54 a2_x2
xsubckt_3580_a2_x2 0 4396 1 215 687 a2_x2
xsubckt_3365_a2_x2 0 4607 1 4608 7215 a2_x2
xsubckt_2651_a2_x2 0 5308 1 203 675 a2_x2
xsubckt_1259_ao22_x2 0 6573 1 6574 6578 7038 ao22_x2
xsubckt_1273_a2_x2 0 6560 1 7143 1854 a2_x2
xsubckt_1340_nor2_x0 1 0 6497 681 56 nor2_x0
xsubckt_1547_a2_x2 0 6294 1 418 202 a2_x2
xsubckt_1738_mx2_x2 0 6104 1 574 6139 6275 mx2_x2
xsubckt_9657_sff1_x4 1 1872 0 8819 830 sff1_x4
xsubckt_9134_sff1_x4 1 1872 0 9324 1150 sff1_x4
xsubckt_7587_oa22_x2 0 7925 1 644 7679 687 oa22_x2
xsubckt_7135_o3_x2 0 8169 1 1742 526 1740 o3_x2
xsubckt_6613_oa22_x2 0 2034 1 40 1741 187 oa22_x2
xsubckt_6397_nand2_x0 1 0 2245 2246 7631 nand2_x0
xsubckt_6219_nand2_x0 1 0 2419 2420 7631 nand2_x0
xsubckt_5791_oa22_x2 0 2832 1 2847 2835 2833 oa22_x2
xsubckt_4763_a2_x2 0 9612 1 3664 3665 a2_x2
xsubckt_4568_a2_x2 0 3769 1 3784 7211 a2_x2
xsubckt_4513_mx3_x2 1 0 9755 3773 3897 1093 3856 3857 mx3_x2
xsubckt_4511_mx3_x2 1 0 9757 3773 3897 1065 3863 3864 mx3_x2
xsubckt_2957_nand3_x0 1 0 5007 5008 5161 5699 nand3_x0
xsubckt_2871_nand2_x0 1 0 5092 5093 5094 nand2_x0
xsubckt_1208_xr2_x1 6622 0 1 688 63 xr2_x1
xsubckt_8757_sff1_x4 1 1872 0 9636 1806 sff1_x4
xsubckt_6039_nand2_x0 1 0 2595 2596 712 nand2_x0
xsubckt_5986_a2_x2 0 2647 1 2648 7613 a2_x2
xsubckt_5247_nand2_x0 1 0 9526 3266 3277 nand2_x0
xsubckt_5171_o2_x2 0 3335 1 3336 3345 o2_x2
xsubckt_4979_oa22_x2 0 9559 1 7168 3501 3503 oa22_x2
xsubckt_4519_mx3_x2 1 0 9749 3773 3896 1087 3838 3840 mx3_x2
xsubckt_4517_mx3_x2 1 0 9751 3773 3896 1089 3844 3846 mx3_x2
xsubckt_4515_mx3_x2 1 0 9753 3773 3896 1091 3850 3852 mx3_x2
xsubckt_2985_a2_x2 0 4980 1 4981 7217 a2_x2
xsubckt_2691_nand2_x0 1 0 5268 7152 7278 nand2_x0
xsubckt_2513_nand2_x0 1 0 5443 5444 5447 nand2_x0
xsubckt_1100_nand3_x0 1 0 6724 384 307 229 nand3_x0
xsubckt_998_nor2_x0 1 0 6821 6822 6823 nor2_x0
xsubckt_1261_o2_x2 0 6571 1 6572 6573 o2_x2
xsubckt_1468_nand2_x0 1 0 6373 186 215 nand2_x0
xsubckt_1559_xr2_x1 6282 0 1 434 218 xr2_x1
xsubckt_1760_oa22_x2 0 6084 1 6135 6116 6112 oa22_x2
xsubckt_1807_nand3_x0 1 0 6042 6043 6044 6111 nand3_x0
xsubckt_9565_sff1_x4 1 1872 0 8908 1206 sff1_x4
xsubckt_9042_sff1_x4 1 1872 0 9384 180 sff1_x4
xsubckt_8041_mx3_x2 1 0 8812 7810 3896 822 3814 3816 mx3_x2
xsubckt_7262_nand2_x0 1 0 8123 8124 8135 nand2_x0
xsubckt_6380_nand2_x0 1 0 2261 2262 7628 nand2_x0
xsubckt_5674_nand3_x0 1 0 2917 2918 5595 5608 nand3_x0
xsubckt_5067_nand2_x0 1 0 3431 3432 7087 nand2_x0
xsubckt_4475_mx3_x2 1 0 9791 3775 3897 1451 3871 3872 mx3_x2
xsubckt_4128_mx3_x2 1 0 10046 3899 3897 1578 3867 3868 mx3_x2
xsubckt_3913_oa22_x2 0 4068 1 7179 4107 4069 oa22_x2
xsubckt_3569_nand3_x0 1 0 4406 4407 4578 5699 nand3_x0
xsubckt_913_oa22_x2 0 6903 1 7041 7126 7283 oa22_x2
xsubckt_1288_nand2_x0 1 0 6546 684 59 nand2_x0
xsubckt_1399_oa22_x2 0 6441 1 384 7044 6880 oa22_x2
xsubckt_2269_o2_x2 0 5683 1 5684 5686 o2_x2
xsubckt_8665_sff1_x4 1 1872 0 9728 1420 sff1_x4
xsubckt_8047_mx3_x2 1 0 8806 7810 3896 815 3797 3798 mx3_x2
xsubckt_8045_mx3_x2 1 0 8808 7810 3896 818 3802 3804 mx3_x2
xsubckt_8043_mx3_x2 1 0 8810 7810 3896 820 3808 3810 mx3_x2
xsubckt_7879_nand2_x0 1 0 7817 3783 3787 nand2_x0
xsubckt_7082_nand2_x0 1 0 8219 943 710 nand2_x0
xsubckt_6909_nand2_x0 1 0 8388 8389 711 nand2_x0
xsubckt_6794_ao22_x2 0 8500 1 8501 8503 708 ao22_x2
xsubckt_6668_o2_x2 0 1980 1 1981 711 o2_x2
xsubckt_6648_o2_x2 0 1999 1 1370 710 o2_x2
xsubckt_5908_ao22_x2 0 2723 1 709 2724 708 ao22_x2
xsubckt_4479_mx3_x2 1 0 9787 3775 3897 1477 3856 3857 mx3_x2
xsubckt_4477_mx3_x2 1 0 9789 3775 3897 1449 3863 3864 mx3_x2
xsubckt_3647_o2_x2 0 4330 1 214 686 o2_x2
xsubckt_2855_ao22_x2 0 10077 1 5147 5109 5108 ao22_x2
xsubckt_2850_nand3_x0 1 0 5112 5113 5266 5699 nand3_x0
xsubckt_987_oa22_x2 0 6832 1 407 7042 6833 oa22_x2
xsubckt_857_nand2_x0 1 0 6956 6957 1737 nand2_x0
xsubckt_1198_nand2_x0 1 0 6631 587 1759 nand2_x0
xsubckt_1598_ao22_x2 0 6243 1 6253 6251 6245 ao22_x2
xsubckt_9473_sff1_x4 1 1872 0 8993 1166 sff1_x4
xsubckt_9038_sff1_x4 1 1872 0 9388 184 sff1_x4
xsubckt_8263_mx2_x2 0 9249 1 5752 9077 650 mx2_x2
xsubckt_8261_mx2_x2 0 9251 1 5752 9079 652 mx2_x2
xsubckt_7905_mx3_x2 1 0 8940 7818 3896 950 3814 3816 mx3_x2
xsubckt_7903_mx3_x2 1 0 8942 7818 3896 952 3820 3822 mx3_x2
xsubckt_7901_mx3_x2 1 0 8944 7818 3896 954 3826 3828 mx3_x2
xsubckt_5371_ao22_x2 0 3150 1 3156 3154 3151 ao22_x2
xsubckt_5316_nand3_x0 1 0 3202 3217 3224 3225 nand3_x0
xsubckt_3946_mx3_x2 1 0 4036 707 705 4037 947 1107 mx3_x2
xsubckt_3663_ao22_x2 0 4314 1 4319 4317 4315 ao22_x2
xsubckt_3422_mx2_x2 0 4551 1 703 4552 4555 mx2_x2
xsubckt_3420_mx2_x2 0 4553 1 705 925 797 mx2_x2
xsubckt_2599_nxr2_x1 5359 1 0 204 676 nxr2_x1
xsubckt_2041_oa22_x2 0 5829 1 5839 6415 6418 oa22_x2
xsubckt_9830_sff1_x4 1 1872 0 8646 1647 sff1_x4
xsubckt_8573_sff1_x4 1 1872 0 9820 1030 sff1_x4
xsubckt_8267_mx2_x2 0 9245 1 5752 9072 646 mx2_x2
xsubckt_8265_mx2_x2 0 9247 1 5752 9074 648 mx2_x2
xsubckt_7909_mx3_x2 1 0 8936 7818 3896 946 3802 3804 mx3_x2
xsubckt_7907_mx3_x2 1 0 8938 7818 3896 948 3808 3810 mx3_x2
xsubckt_7863_mx3_x2 1 0 8980 7820 3896 1183 3838 3840 mx3_x2
xsubckt_7861_mx3_x2 1 0 8982 7820 3896 1185 3844 3846 mx3_x2
xsubckt_7275_inv_x0 1 0 8114 9082 inv_x0
xsubckt_7271_inv_x0 1 0 8117 9081 inv_x0
xsubckt_3905_nand2_x0 1 0 4076 7153 7260 nand2_x0
xsubckt_3773_mx2_x2 0 4206 1 705 1206 1078 mx2_x2
xsubckt_3771_mx2_x2 0 4208 1 705 1142 982 mx2_x2
xsubckt_3428_mx2_x2 0 4545 1 705 765 1629 mx2_x2
xsubckt_3426_mx2_x2 0 4547 1 705 1213 1085 mx2_x2
xsubckt_2631_mx3_x2 1 0 5327 703 7218 5328 5337 5339 mx3_x2
xsubckt_707_a2_x2 0 7094 1 7789 1740 a2_x2
xsubckt_1978_nand2_x0 1 0 5887 6198 6332 nand2_x0
xsubckt_9826_sff1_x4 1 1872 0 8650 1652 sff1_x4
xsubckt_9469_sff1_x4 1 1872 0 8997 1192 sff1_x4
xsubckt_9381_sff1_x4 1 1872 0 9080 370 sff1_x4
xsubckt_8930_sff1_x4 1 1872 0 9463 1828 sff1_x4
xsubckt_8569_sff1_x4 1 1872 0 9824 1004 sff1_x4
xsubckt_7867_mx3_x2 1 0 8976 7820 3896 1178 3826 3828 mx3_x2
xsubckt_7865_mx3_x2 1 0 8978 7820 3896 1181 3832 3834 mx3_x2
xsubckt_7598_ao22_x2 0 9179 1 7956 7917 7919 ao22_x2
xsubckt_7399_oa22_x2 0 9271 1 8037 8022 8024 oa22_x2
xsubckt_7277_inv_x0 1 0 8113 9083 inv_x0
xsubckt_7244_nor2_x0 1 0 8137 373 372 nor2_x0
xsubckt_6459_nand2_x0 1 0 2184 2185 712 nand2_x0
xsubckt_6425_oa22_x2 0 2217 1 2218 2231 2728 oa22_x2
xsubckt_4151_a4_x2 0 3848 1 3858 73 72 71 a4_x2
xsubckt_3775_mx2_x2 0 4204 1 706 4205 4207 mx2_x2
xsubckt_3386_mx2_x2 0 4586 1 705 1470 1310 mx2_x2
xsubckt_2995_oa22_x2 0 4970 1 4971 705 706 oa22_x2
xsubckt_2502_mx2_x2 0 5454 1 705 764 1628 mx2_x2
xsubckt_840_nand2_x0 1 0 6972 588 1784 nand2_x0
xsubckt_231_inv_x0 1 0 1515 7560 inv_x0
xsubckt_233_inv_x0 1 0 1387 7558 inv_x0
xsubckt_2059_nand3_x0 1 0 5812 5813 5814 5815 nand3_x0
xsubckt_2244_mx3_x2 1 0 5707 7620 712 5710 5708 5709 mx3_x2
xsubckt_9377_sff1_x4 1 1872 0 9084 374 sff1_x4
xsubckt_9303_sff1_x4 1 1872 0 9158 1351 sff1_x4
xsubckt_8926_sff1_x4 1 1872 0 9467 1832 sff1_x4
xsubckt_8481_sff1_x4 1 1872 0 9912 1538 sff1_x4
xsubckt_8403_sff1_x4 1 1872 0 9990 904 sff1_x4
xsubckt_7869_mx3_x2 1 0 8974 7820 3896 1176 3820 3822 mx3_x2
xsubckt_6890_nand2_x0 1 0 8406 8407 7628 nand2_x0
xsubckt_6712_nand2_x0 1 0 1937 1938 709 nand2_x0
xsubckt_6333_oa22_x2 0 2307 1 2308 2321 2728 oa22_x2
xsubckt_6175_ao22_x2 0 2462 1 711 2474 708 ao22_x2
xsubckt_4681_nand4_x0 1 0 3730 3735 3745 1746 1805 nand4_x0
xsubckt_3635_nand2_x0 1 0 4341 7152 7260 nand2_x0
xsubckt_3388_mx2_x2 0 4584 1 707 4585 4586 mx2_x2
xsubckt_3282_nand3_x0 1 0 4688 4689 4840 7104 nand3_x0
xsubckt_2722_nor3_x0 1 0 5238 5239 5241 7218 nor3_x0
xsubckt_924_ao22_x2 0 6892 1 6893 6897 7038 ao22_x2
xsubckt_582_inv_x0 1 0 519 7209 inv_x0
xsubckt_580_inv_x0 1 0 521 7211 inv_x0
xsubckt_191_inv_x0 1 0 1543 7600 inv_x0
xsubckt_235_inv_x0 1 0 1227 7556 inv_x0
xsubckt_237_inv_x0 1 0 1002 7554 inv_x0
xsubckt_239_inv_x0 1 0 810 7552 inv_x0
xsubckt_1771_ao22_x2 0 6075 1 6082 6264 6265 ao22_x2
xsubckt_9734_sff1_x4 1 1872 0 8742 751 sff1_x4
xsubckt_9211_sff1_x4 1 1872 0 9247 648 sff1_x4
xsubckt_8477_sff1_x4 1 1872 0 9916 1542 sff1_x4
xsubckt_6796_nand3_x0 1 0 8498 8499 8508 709 nand3_x0
xsubckt_6189_nand2_x0 1 0 2448 2449 7631 nand2_x0
xsubckt_6030_mx2_x2 0 2604 1 712 1194 1162 mx2_x2
xsubckt_5402_a3_x2 1 3122 0 40 118 7780 a3_x2
xsubckt_4680_a4_x2 0 3731 1 3735 3745 1746 1805 a4_x2
xsubckt_2753_nand2_x0 1 0 5207 5208 5254 nand2_x0
xsubckt_2663_nand2_x0 1 0 5296 5297 706 nand2_x0
xsubckt_799_oa22_x2 0 7011 1 7012 7013 7015 oa22_x2
xsubckt_197_inv_x0 1 0 1244 7594 inv_x0
xsubckt_195_inv_x0 1 0 1500 7596 inv_x0
xsubckt_193_inv_x0 1 0 967 7598 inv_x0
xsubckt_2387_nor2_x0 1 0 5567 705 1128 nor2_x0
xsubckt_9285_sff1_x4 1 1872 0 9176 693 sff1_x4
xsubckt_8834_sff1_x4 1 1872 0 9559 70 sff1_x4
xsubckt_8311_sff1_x4 1 1872 0 10074 227 sff1_x4
xsubckt_6818_mx2_x2 0 8477 1 710 918 790 mx2_x2
xsubckt_5646_nand3_x0 1 0 2937 2943 1819 1820 nand3_x0
xsubckt_5632_ao22_x2 0 2947 1 2951 1823 40 ao22_x2
xsubckt_5510_a2_x2 0 3036 1 3039 1860 a2_x2
xsubckt_5287_a3_x2 1 3229 0 3252 3483 3486 a3_x2
xsubckt_3195_nor2_x0 1 0 4774 4775 4830 nor2_x0
xsubckt_2910_a3_x2 1 5053 0 5054 5055 5057 a3_x2
xsubckt_2749_nand3_x0 1 0 5211 5212 5375 5699 nand3_x0
xsubckt_950_o2_x2 0 6867 1 6868 6869 o2_x2
xsubckt_199_inv_x0 1 0 956 7592 inv_x0
xsubckt_1691_nand2_x0 1 0 6150 7236 206 nand2_x0
xsubckt_2119_a2_x2 0 5764 1 5765 5766 a2_x2
xsubckt_2314_a2_x2 0 5639 1 5640 7625 a2_x2
xsubckt_9642_sff1_x4 1 1872 0 8834 817 sff1_x4
xsubckt_9207_sff1_x4 1 1872 0 9251 652 sff1_x4
xsubckt_8385_sff1_x4 1 1872 0 10000 1561 sff1_x4
xsubckt_7622_a2_x2 0 9175 1 7897 7901 a2_x2
xsubckt_6963_ao22_x2 0 8335 1 723 710 712 ao22_x2
xsubckt_6518_a2_x2 0 9394 1 2127 2173 a2_x2
xsubckt_6387_mx2_x2 0 2255 1 712 992 960 mx2_x2
xsubckt_6352_nand2_x0 1 0 2289 2290 2293 nand2_x0
xsubckt_5429_oa22_x2 0 3096 1 7087 3097 3099 oa22_x2
xsubckt_4867_a3_x2 1 9587 0 3585 3587 40 a3_x2
xsubckt_4661_a2_x2 0 9632 1 3746 3747 a2_x2
xsubckt_4466_a2_x2 0 3775 1 3780 3900 a2_x2
xsubckt_3961_nor3_x0 1 0 4021 4022 4038 5585 nor3_x0
xsubckt_3537_a2_x2 0 4438 1 4439 7218 a2_x2
xsubckt_3110_oa22_x2 0 4857 1 4858 4859 4869 oa22_x2
xsubckt_2970_a3_x2 1 4995 0 4996 4999 7179 a3_x2
xsubckt_829_nand2_x0 1 0 6983 6984 1737 nand2_x0
xsubckt_629_oa22_x2 0 10098 1 309 7169 7163 oa22_x2
xsubckt_1425_a2_x2 0 6416 1 180 209 a2_x2
xsubckt_1445_a2_x2 0 6396 1 6397 6402 a2_x2
xsubckt_1513_nand2_x0 1 0 6328 193 223 nand2_x0
xsubckt_1777_nand3_x0 1 0 6069 6070 6071 6111 nand3_x0
xsubckt_1935_mx2_x2 0 5926 1 574 5927 5930 mx2_x2
xsubckt_2199_a2_x2 0 5751 1 7096 7180 a2_x2
xsubckt_9193_sff1_x4 1 1872 0 9265 660 sff1_x4
xsubckt_8742_sff1_x4 1 1872 0 9651 1277 sff1_x4
xsubckt_8307_sff1_x4 1 1872 0 10078 201 sff1_x4
xsubckt_7121_o2_x2 0 8181 1 1742 1740 o2_x2
xsubckt_6436_ao22_x2 0 2207 1 7620 2211 2208 ao22_x2
xsubckt_6389_mx2_x2 0 2253 1 710 2254 2255 mx2_x2
xsubckt_6172_nand2_x0 1 0 2465 2467 7628 nand2_x0
xsubckt_5290_nand2_x0 1 0 3226 3483 665 nand2_x0
xsubckt_4321_mx3_x2 1 0 9931 3789 3896 724 3808 3810 mx3_x2
xsubckt_3383_ao22_x2 0 4589 1 926 705 707 ao22_x2
xsubckt_1310_oa22_x2 0 6525 1 390 7044 6880 oa22_x2
xsubckt_1333_nand2_x0 1 0 6503 587 1752 nand2_x0
xsubckt_1485_a2_x2 0 6356 1 191 221 a2_x2
xsubckt_1675_ao22_x2 0 6166 1 6169 6181 6381 ao22_x2
xsubckt_1759_a2_x2 0 6085 1 6114 6136 a2_x2
xsubckt_1940_nand3_x0 1 0 5921 5922 5923 5924 nand3_x0
xsubckt_9638_sff1_x4 1 1872 0 10096 307 sff1_x4
xsubckt_9550_sff1_x4 1 1872 0 8923 1222 sff1_x4
xsubckt_9115_sff1_x4 1 1872 0 1911 1879 sff1_x4
xsubckt_8738_sff1_x4 1 1872 0 9655 1281 sff1_x4
xsubckt_6789_nand2_x0 1 0 8505 8506 7628 nand2_x0
xsubckt_5729_nand2_x0 1 0 2862 2863 2870 nand2_x0
xsubckt_5091_ao22_x2 0 3409 1 3425 3424 3423 ao22_x2
xsubckt_4325_mx3_x2 1 0 9927 3789 3896 719 3797 3798 mx3_x2
xsubckt_4323_mx3_x2 1 0 9929 3789 3896 722 3802 3804 mx3_x2
xsubckt_3211_o2_x2 0 4758 1 4759 704 o2_x2
xsubckt_3036_o2_x2 0 4930 1 705 740 o2_x2
xsubckt_2483_ao22_x2 0 5473 1 7593 707 705 ao22_x2
xsubckt_933_nxr2_x1 6884 1 0 6886 6887 nxr2_x1
xsubckt_1365_xr2_x1 6473 0 1 680 55 xr2_x1
xsubckt_1384_oa22_x2 0 6455 1 385 7044 6880 oa22_x2
xsubckt_1413_o2_x2 0 6428 1 177 205 o2_x2
xsubckt_1799_a2_x2 0 6049 1 6114 6300 a2_x2
xsubckt_1850_nand3_x0 1 0 6003 6004 6005 6111 nand3_x0
xsubckt_2302_o2_x2 0 5651 1 5652 7628 o2_x2
xsubckt_9189_sff1_x4 1 1872 0 9269 664 sff1_x4
xsubckt_8650_sff1_x4 1 1872 0 9743 1080 sff1_x4
xsubckt_8240_mx3_x2 1 0 8593 7798 3896 1627 3829 3831 mx3_x2
xsubckt_6699_nand2_x0 1 0 1949 1950 7620 nand2_x0
xsubckt_6506_o2_x2 0 2138 1 1374 710 o2_x2
xsubckt_5206_nxr2_x1 3303 1 0 3321 3504 nxr2_x1
xsubckt_4934_mx2_x2 0 3534 1 5753 3883 114 mx2_x2
xsubckt_4930_mx2_x2 0 3537 1 5753 3887 117 mx2_x2
xsubckt_4541_mx2_x2 0 9729 1 3770 3878 1421 mx2_x2
xsubckt_4283_mx3_x2 1 0 9966 3792 3896 887 3817 3819 mx3_x2
xsubckt_4281_mx3_x2 1 0 9968 3792 3896 889 3823 3825 mx3_x2
xsubckt_4150_mx2_x2 0 3849 1 518 102 1898 mx2_x2
xsubckt_3972_oa22_x2 0 4011 1 5595 5608 208 oa22_x2
xsubckt_3410_nxr2_x1 4563 1 0 4564 4567 nxr2_x1
xsubckt_2905_nand2_x0 1 0 5058 7153 7279 nand2_x0
xsubckt_2616_o2_x2 0 5342 1 705 1390 o2_x2
xsubckt_2560_nor2_x0 1 0 5397 5398 704 nor2_x0
xsubckt_990_nand2_x0 1 0 6829 6830 1737 nand2_x0
xsubckt_1239_nand3_x0 1 0 6592 6593 6594 6595 nand3_x0
xsubckt_1670_nand3_x0 1 0 6171 6376 7228 215 nand3_x0
xsubckt_1707_o2_x2 0 6134 1 423 207 o2_x2
xsubckt_9546_sff1_x4 1 1872 0 8927 1196 sff1_x4
xsubckt_9023_sff1_x4 1 1872 0 9403 175 sff1_x4
xsubckt_8646_sff1_x4 1 1872 0 9747 1085 sff1_x4
xsubckt_8246_mx3_x2 1 0 8587 7798 3896 1621 3811 3813 mx3_x2
xsubckt_8244_mx3_x2 1 0 8589 7798 3896 1623 3817 3819 mx3_x2
xsubckt_8242_mx3_x2 1 0 8591 7798 3896 1625 3823 3825 mx3_x2
xsubckt_6701_ao22_x2 0 1947 1 534 532 687 ao22_x2
xsubckt_4938_mx2_x2 0 3531 1 5753 3879 113 mx2_x2
xsubckt_4667_nand2_x0 1 0 3741 3745 1746 nand2_x0
xsubckt_4289_mx3_x2 1 0 9960 3792 3896 880 3799 3801 mx3_x2
xsubckt_4287_mx3_x2 1 0 9962 3792 3896 883 3805 3807 mx3_x2
xsubckt_4285_mx3_x2 1 0 9964 3792 3896 885 3811 3813 mx3_x2
xsubckt_4154_mx2_x2 0 3846 1 518 101 1897 mx2_x2
xsubckt_3861_nand4_x0 1 0 4119 5604 532 7689 58 nand4_x0
xsubckt_3585_o2_x2 0 4391 1 4392 707 o2_x2
xsubckt_3456_nor2_x0 1 0 4518 4519 7180 nor2_x0
xsubckt_3088_oa22_x2 0 4879 1 4883 4943 7180 oa22_x2
xsubckt_1727_o2_x2 0 6114 1 608 609 o2_x2
xsubckt_1933_nand2_x0 1 0 5928 6339 6345 nand2_x0
xsubckt_9454_sff1_x4 1 1872 0 9012 1407 sff1_x4
xsubckt_9097_sff1_x4 1 1872 0 1931 1899 sff1_x4
xsubckt_9019_sff1_x4 1 1872 0 9407 419 sff1_x4
xsubckt_8248_mx3_x2 1 0 8585 7798 3896 1619 3805 3807 mx3_x2
xsubckt_8119_mx2_x2 0 8708 1 7803 3892 1703 mx2_x2
xsubckt_6775_ao22_x2 0 8519 1 8523 8522 8520 ao22_x2
xsubckt_6682_nand2_x0 1 0 1966 1967 7631 nand2_x0
xsubckt_6504_nand2_x0 1 0 2140 2141 711 nand2_x0
xsubckt_5890_nand2_x0 1 0 9411 2738 2740 nand2_x0
xsubckt_5712_nand2_x0 1 0 2879 2880 7219 nand2_x0
xsubckt_5676_oa22_x2 0 2915 1 3957 3960 3961 oa22_x2
xsubckt_5188_nxr2_x1 3320 1 0 3327 3507 nxr2_x1
xsubckt_4158_mx2_x2 0 3843 1 518 100 1896 mx2_x2
xsubckt_3644_ao22_x2 0 4333 1 4400 4398 4395 ao22_x2
xsubckt_3074_nand3_x0 1 0 4892 4893 5058 5699 nand3_x0
xsubckt_896_nand3_x0 1 0 6919 6920 6922 6923 nand3_x0
xsubckt_802_oa22_x2 0 7009 1 7041 7126 7640 oa22_x2
xsubckt_9811_sff1_x4 1 1872 0 8665 1668 sff1_x4
xsubckt_8554_sff1_x4 1 1872 0 9839 1496 sff1_x4
xsubckt_7719_mx3_x2 1 0 9146 7830 3896 1347 3850 3852 mx3_x2
xsubckt_7717_mx3_x2 1 0 9148 7830 3897 1349 3856 3857 mx3_x2
xsubckt_5352_ao22_x2 0 3168 1 3205 3173 3170 ao22_x2
xsubckt_4776_oa22_x2 0 3654 1 3657 1786 1785 oa22_x2
xsubckt_721_nor2_x0 1 0 7082 532 534 nor2_x0
xsubckt_1929_nand3_x0 1 0 5931 5932 5933 5934 nand3_x0
xsubckt_2350_nor3_x0 1 0 5604 1739 1738 1737 nor3_x0
xsubckt_9885_sff1_x4 1 1872 0 8591 1625 sff1_x4
xsubckt_9362_sff1_x4 1 1872 0 9099 1043 sff1_x4
xsubckt_8911_sff1_x4 1 1872 0 9482 1849 sff1_x4
xsubckt_6683_ao22_x2 0 1965 1 1970 1968 1966 ao22_x2
xsubckt_5149_oa22_x2 0 3356 1 3362 3363 3364 oa22_x2
xsubckt_5061_oa22_x2 0 3437 1 3451 3442 3443 oa22_x2
xsubckt_2455_nand2_x0 1 0 5500 5501 5502 nand2_x0
xsubckt_919_a2_x2 0 6897 1 7143 1810 a2_x2
xsubckt_430_inv_x0 1 0 1487 7361 inv_x0
xsubckt_432_inv_x0 1 0 1327 7359 inv_x0
xsubckt_434_inv_x0 1 0 1103 7357 inv_x0
xsubckt_1196_oa22_x2 0 6633 1 396 7044 6880 oa22_x2
xsubckt_1321_ao22_x2 0 6515 1 6533 6528 6530 ao22_x2
xsubckt_2018_oa22_x2 0 5850 1 6385 5862 6160 oa22_x2
xsubckt_2310_mx2_x2 0 5643 1 711 1038 942 mx2_x2
xsubckt_9807_sff1_x4 1 1872 0 8669 1642 sff1_x4
xsubckt_8985_sff1_x4 1 1872 0 9440 486 sff1_x4
xsubckt_8462_sff1_x4 1 1872 0 9931 724 sff1_x4
xsubckt_5506_a4_x2 0 3039 1 3047 1861 1862 1863 a4_x2
xsubckt_4196_nxr2_x1 3814 1 0 3818 59 nxr2_x1
xsubckt_3589_mx2_x2 0 4387 1 705 1369 857 mx2_x2
xsubckt_3349_oa22_x2 0 4623 1 1694 7217 4624 oa22_x2
xsubckt_2895_nor2_x0 1 0 5068 5069 5072 nor2_x0
xsubckt_2709_mx2_x2 0 5251 1 707 5252 5253 mx2_x2
xsubckt_2707_mx2_x2 0 5253 1 705 908 780 mx2_x2
xsubckt_2661_mx2_x2 0 5298 1 705 1005 813 mx2_x2
xsubckt_983_ao22_x2 0 6836 1 6860 6838 6841 ao22_x2
xsubckt_784_oa22_x2 0 7026 1 7050 7053 7296 oa22_x2
xsubckt_390_inv_x0 1 0 916 7401 inv_x0
xsubckt_436_inv_x0 1 0 85 7355 inv_x0
xsubckt_438_inv_x0 1 0 82 7353 inv_x0
xsubckt_1305_nand2_x0 1 0 6530 683 58 nand2_x0
xsubckt_2217_ao22_x2 0 5734 1 712 5738 5735 ao22_x2
xsubckt_2372_nor2_x0 1 0 5582 705 1192 nor2_x0
xsubckt_9793_sff1_x4 1 1872 0 8683 1685 sff1_x4
xsubckt_9358_sff1_x4 1 1872 0 9103 1047 sff1_x4
xsubckt_9270_sff1_x4 1 1872 0 9191 519 sff1_x4
xsubckt_8907_sff1_x4 1 1872 0 9486 1853 sff1_x4
xsubckt_7031_a2_x2 0 8269 1 8270 7625 a2_x2
xsubckt_6620_mx2_x2 0 2027 1 712 1082 1050 mx2_x2
xsubckt_6019_mx3_x2 1 0 2614 7620 7613 2615 2620 2623 mx3_x2
xsubckt_6017_mx3_x2 1 0 2616 712 710 2617 1579 715 mx3_x2
xsubckt_5860_nor2_x0 1 0 2767 1671 710 nor2_x0
xsubckt_5320_a3_x2 1 3198 0 3199 3202 3205 a3_x2
xsubckt_5172_nand2_x0 1 0 9532 3335 3346 nand2_x0
xsubckt_4080_nor2_x0 1 0 3905 519 520 nor2_x0
xsubckt_3548_ao22_x2 0 4427 1 7454 7218 705 ao22_x2
xsubckt_3460_ao22_x2 0 4514 1 7219 4515 7218 ao22_x2
xsubckt_2648_ao22_x2 0 10081 1 5311 5313 5316 ao22_x2
xsubckt_999_a2_x2 0 6820 1 6821 6829 a2_x2
xsubckt_392_inv_x0 1 0 788 7399 inv_x0
xsubckt_394_inv_x0 1 0 1396 7397 inv_x0
xsubckt_396_inv_x0 1 0 1236 7395 inv_x0
xsubckt_2270_mx2_x2 0 5682 1 711 1201 1137 mx2_x2
xsubckt_2272_mx2_x2 0 5680 1 711 1073 977 mx2_x2
.ends picorv32
